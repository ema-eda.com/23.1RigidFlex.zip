# Allegro board RigidFlex.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
A14: length 29.6
  TOP w0.2: v2(24.3,118.24) 24.31,118.24 24.46,118.09 U8.38
  INNER1 w0.2: J6.B10 14.08,99.83 14.45,100.2 14.45,109.1 14.75,109.4 18.67,109.4 20.4,111.14 20.4,113.15 22.7,115.44 22.7,116.75 23.05,117.11 23.16,117.11 v2(24.3,118.24)
A15: length 33
  TOP w0.2: U8.37 26.89,117.59 v2(26.9,117.6)
  INNER1 w0.2: J6.B9 10.88,97.3 13.75,97.3 14.85,98.4 14.85,108.8 15.05,109 18.83,109 20.8,110.97 20.8,112.98 25.42,117.6 v2(26.9,117.6)
A16: length 24.1
  TOP w0.2: J6.B24 12.24,135.39 12.9,136.05 12.9,137.88 16.52,141.51 20.71,141.51 21.95,140.26 21.95,139.94 21.95,139.93 21.95,138 23.55,136.4 23.55,134.86 23.54,134.85 23.54,134.35 24.03,133.86 24.83,133.86 24.84,133.86 U6.36
A17: length 25.4
  TOP w0.2: U6.35 24.6,133.36 24.55,133.41 23.92,133.41 23.14,134.18 23.14,136.24 21.55,137.84 21.55,140.1 20.54,141.11 16.69,141.11 13.3,137.72 13.3,135.75 11.77,134.22 11.77,133.75 J6.B23
A18: length 93.9
  TOP w0.2: U6.33 24.74,132.36 v2(24.3,132.8) 23.8,132.8 22.74,133.86 22.74,136.08 21.15,137.67 21.15,139.93 20.38,140.71 16.85,140.71 13.7,137.55 13.7,131.62 12.39,130.31 J6.B22 ; v2(18.1,81.9) 18.1,81.85 17.78,81.53 U7.6
  INNER2 w0.2: v2(24.3,132.8) 26.14,130.96 26.14,128.03 24.97,126.85 23.5,126.85 22.3,125.65 22.3,120.48 21.6,119.78 21.6,117.04 29.2,109.45 29.2,90.63 20.41,81.84 18.15,81.84 v2(18.1,81.9)
A19: length 94.3
  TOP w0.2: J6.B21 13.27,127.77 14.1,128.6 14.1,137.39 17.02,140.31 20.21,140.31 20.75,139.77 20.75,137.51 22.34,135.91 22.34,133.69 24.13,131.9 v2(24.3,131.9) 25.6,131.9 U6.32 ; v2(18,82.8) U7.5
  INNER2 w0.2: v2(24.3,131.9) 25.74,130.46 25.74,128.19 24.8,127.25 23.34,127.25 21.9,125.81 21.9,120.65 21.2,119.95 21.2,117.21 21.2,117.21 21.2,116.88 28.8,109.28 28.8,90.8 21.15,83.15 19.2,83.15 18.84,82.8 v2(18,82.8)
A20: length 80.6
  TOP w0.2: v2(24.05,130.95) 24.05,130.95 24.15,130.85 25.64,130.85 U6.30 ; v2(18.74,84.1) 16.67,84.1 U7.4
  INNER1 w0.2: v2(24.05,130.95) 23.59,130.5 18.15,130.5 17.5,131.15 16.1,131.15 14.6,129.65 11.54,129.65 10.02,128.12 10.02,127.42 10.87,126.57 J6.B20
  INNER2 w0.2: v2(18.74,84.1) 18.74,85.75 20.15,87.16 24.02,87.16 28,91.13 28,106.77 20.4,114.36 20.4,116.55 20.4,116.55 20.4,117.21 20.4,117.54 20.4,117.54 20.4,120.28 21.1,120.98 21.1,126.14 23.8,128.85 23.8,129.54 23.49,129.85 23.49,130.4 v2(24.05,130.95)
A21: length 79.9
  TOP w0.2: 16.64,85.34 16.7,85.4 19.25,85.4 v2(20.4,86.55) ; v2(24.1,130.1) 24.35,130.35 25.64,130.35 U6.29
  INNER1 w0.2: J6.B19 11.77,123.59 11.77,127.11 12.26,127.61 13.1,127.61 14.75,129.25 14.77,129.25 16.22,130.7 17.38,130.7 17.98,130.1 v2(24.1,130.1)
  INNER2 w0.2: v2(24.1,130.1) 24.15,130.1 25.02,129.23 25.02,128.11 24.56,127.65 23.17,127.65 21.5,125.98 21.5,120.81 20.8,120.12 20.8,117.38 20.8,116.71 20.8,116.71 20.8,114.53 28.4,106.93 28.4,90.96 23.98,86.55 v2(20.4,86.55)
A22: length 83.3
  TOP w0.2: v2(14.5,86.6) 14.51,86.61 U7.2 ; U6.27 23.46,129.36 v2(23.2,129.1)
  INNER1 w0.2: J6.B18 13.33,120.15 14,120.82 14,124.03 13.25,124.78 13.25,125.28 13.24,125.28 13.24,126.16 13.64,126.56 13.64,127.42 14.73,128.5 15.6,128.5 16.14,129.05 16.14,129.05 16.5,129.41 17,129.41 17.01,129.4 17.9,129.4 18.2,129.7 22.6,129.7 v2(23.2,129.1)
  INNER2 w0.2: v2(23.2,129.1) 20.7,126.6 20.7,121.14 20,120.45 20,117.71 20,117.38 20,117.38 20,116.38 20,116.38 20,114.19 27.6,106.6 27.6,91.3 23.86,87.56 19.96,87.56 19,86.6 v2(14.5,86.6)
A23: length 27.2
  TOP w0.2: U6.26 25.69,128.9 v2(26.95,128.9)
  INNER1 w0.2: v2(26.95,128.9) 26.89,128.96 23.96,128.96 23.4,128.4 17.4,128.4 17.1,128.11 14.9,128.11 14.04,127.25 14.04,126.39 13.64,126 13.64,125.45 13.65,125.44 13.65,124.95 14.4,124.2 14.4,120.65 13.22,119.48 12.02,119.48 10.87,118.32 J6.B17
AEN/: length 12.6
  TOP w0.2: 16.64,80.26 16.56,80.19 11.39,80.19 10.58,81 10.25,81 9.15,82.1 4.92,82.1 J6.E3
BRD/: length 21.5
  TOP w0.2: U7.13 22.69,78.99 22.1,78.4 22.1,67.65 19.5,65.05 16.67,65.05 U48.7
BRESET: length 21.4
  TOP w0.2: U7.12 26,77.75 23.05,77.75 22.5,77.2 22.5,66.6 19.65,63.75 U48.8
BUF_OUT: length 1.4
  TOP w0.5: R50.1 C41.2
BWR/: length 21.3
  TOP w0.2: U48.6 18.94,66.29 21.7,69.05 21.7,79.4 22.6,80.3 25.99,80.3 26.04,80.26
CENTER-TAP: length 2
  TOP w0.5: R21.2 C41.1
CLKC: length 85.8
  TOP w0.102: U1.C3 52.85,121.25 55.5,121.25
  TOP w0.2: 55.5,121.25 v2(56.05,121.25)
  INNER1 w0.2: v2(56.05,121.25) 64.8,121.25 66.74,119.31 66.74,119.2 67.1,118.84 67.21,118.84 69.8,116.25 82.25,116.25 83.2,115.3 83.2,105.15 80.8,102.75 80.8,71.3 v2(76.92,67.42)
  BOTTOM w0.2: R26.1 v2(76.92,67.42)
CLOCK+: length 59.1
  TOP w0.1: U1.H4 51.6,126.7 v1(51.9,126.4) ; U2.J11 61.97,95.65 62.2,95.42 v1(62.2,95.3)
  TOP w0.127: U50.31 67.92,83.75 68.35,83.75 68.43,83.67 69.27,83.67 69.75,84.15 69.75,85.57 v2(69.47,85.85)
  INNER1 w0.1: v1(51.9,126.4) 52.09,126.59 53.64,126.59 55,125.23 55,124.23 55.3,123.93 55.3,122.06 54.97,121.73 54.97,119.67 55.27,119.37 55.55,119.37 55.56,119.36 55.59,119.36 ; 67.77,94.03 67.75,94.05 67.75,94.07 67.47,94.35 64.18,94.35 63.25,95.27 62.5,95.27 62.48,95.3 v1(62.2,95.3) 62,95.53 61.9,95.53 59.79,95.53 59.02,96.31 59.02,104.63 59.01,104.64 59.01,104.67
  INNER1 w0.127: v2(69.47,85.85) 69.75,86.13 69.75,88.45 68.1,90.1 68.1,93.7 67.77,94.03 ; 59.01,104.67 59.01,112.01 56.45,114.57 56.45,119.03 56.12,119.36 55.59,119.36
CLOCK-: length 60.3
  TOP w0.1: v1(62.25,95.95) 62.25,95.8 62.4,95.65 U2.J12 ; U1.H3 52.2,126.7 v1(51.9,127)
  TOP w0.127: v2(70.28,85.85) 70,85.57 70,84.04 69.38,83.42 68.42,83.42 68.35,83.35 67.94,83.35 U50.30
  INNER1 w0.1: 67.94,94.22 67.93,94.23 67.91,94.23 67.56,94.58 64.27,94.58 63.35,95.5 62.6,95.5 62.25,95.85 v1(62.25,95.95) 62.02,95.75 61.92,95.76 59.89,95.76 59.25,96.4 59.25,104.63 59.26,104.64 59.26,104.67 ; v1(51.9,127) 51.9,126.95 52.04,126.81 53.74,126.81 55.22,125.33 55.22,124.33 55.53,124.02 55.53,121.97 55.2,121.64 55.2,119.76 55.36,119.6 55.58,119.6 55.59,119.61
  INNER1 w0.127: 67.94,94.22 68.35,93.81 68.35,90.21 70,88.56 70,86.13 v2(70.28,85.85) ; 59.26,104.67 59.26,112.11 56.7,114.68 56.7,119.14 56.22,119.61 55.59,119.61
CONF_SW0: length 40.5
  TOP w0.102: U1.T11 v1(43.9,135.2)
  TOP w0.2: v2(61.75,127.45) 61.75,127.65 62.5,128.4 62.5,132.85 64.15,134.5 66.51,134.5 SW1.1
  INNER1 w0.102: v1(43.9,135.2) 43.34,134.64 43.34,130.22 44.96,128.6 55.59,128.6
  INNER1 w0.2: 55.59,128.6 55.63,128.6 55.88,128.35 59.5,128.35 60.39,127.45 61.2,127.45 61.2,127.45 v2(61.75,127.45)
  BOTTOM w0.2: RN1.1 62,127.2 v2(61.75,127.45)
CONF_SW1: length 34.7
  TOP w0.102: U1.R11 v1(43.9,134.2)
  TOP w0.2: SW1.2 63.95,131.95 63.25,131.25 63.25,130.41 63.24,130.4 63.24,129.9 63.25,129.89 v2(63.25,128.9) 63.25,128.88
  INNER1 w0.102: v1(43.9,134.2) 43.52,133.82 43.52,130.38 44.3,129.6 55.54,129.6 55.59,129.55
  INNER1 w0.2: v2(63.25,128.9) 63.25,128.88 63.11,128.74 61.23,128.74 60.42,129.55 55.59,129.55
  BOTTOM w0.2: RN1.2 64.4,127.6 63.67,128.33 63.67,128.48 v2(63.25,128.9)
CONF_SW2: length 24.2
  TOP w0.102: U1.N8 v1(47.9,132.2)
  TOP w0.2: v2(64.5,128.6) 64.54,128.64 64.54,129.1 64.85,129.41 SW1.3
  INNER1 w0.102: 55.59,130.35 55.4,130.35 55.17,130.58 49.52,130.58 v1(47.9,132.2)
  INNER1 w0.2: v2(64.5,128.6) 64.5,129.9 64.05,130.35 55.59,130.35
  BOTTOM w0.2: RN1.3 65.1,128 v2(64.5,128.6)
CONF_SW3: length 26.4
  TOP w0.102: U1.M9 v1(46.88,130.22)
  TOP w0.2: v2(63.85,129.65) 63.85,129.65 63.85,127.59 64.65,126.8 66.45,126.8 SW1.4
  INNER1 w0.102: 55.59,129.95 55.44,129.8 47.3,129.8 v1(46.88,130.22)
  INNER1 w0.2: 55.59,129.95 60.59,129.95 61.4,129.14 62.59,129.14 63.1,129.65 v2(63.85,129.65) 63.85,129.65
  BOTTOM w0.2: v2(63.85,129.65) 64.7,129.65 65.95,128.4 RN1.4
D0: length 36.5
  TOP w0.2: v2(24.3,111.95) 24.4,112.05 25.6,112.05 U8.26 ; U9.37 23.52,100.58 v2(23.45,100.65)
  INNER2 w0.2: J6.E8 9.5,94.75 10.95,96.2 11.15,96.2 12.35,97.4 14,97.4 15.1,98.5 17.8,98.5 18.4,99.1 21.9,99.1 v2(23.45,100.65)
  BOTTOM w0.2: v2(23.45,100.65) 23.45,101.24 24.7,102.5 24.7,111.55 v2(24.3,111.95)
D1: length 36.4
  TOP w0.2: U8.27 25.59,112.64 24.5,112.64 24.3,112.84 v2(24.3,112.9) ; v2(24.32,101.25) 24.49,101.08 U9.38
  INNER2 w0.2: v2(24.32,101.25) 24.31,101.25 23.71,101.25 23.7,101.25 23.2,101.25 22.39,100.45 18.45,100.45 16.99,99 14.35,99 14.1,99.25 11.9,99.25 11.4,98.75 10.8,98.75 9.34,97.29 J6.E9
  BOTTOM w0.2: v2(24.3,112.9) 25.15,112.05 25.15,102.09 v2(24.32,101.25)
D2: length 37.7
  TOP w0.2: U8.29 25.59,113.64 24.79,113.64 24.74,113.7 23.85,113.7 21.84,111.69 21.84,103.06 22.8,102.1 v2(23.45,102.1) 25.49,102.1 U9.40
  INNER2 w0.2: J6.E10 9.46,99.83 10.31,100.68 11.22,100.68 11.45,100.45 14.3,100.45 15.9,102.05 17.4,102.05 18.15,102.8 21.3,102.8 21.7,102.4 22.31,102.4 22.61,102.1 v2(23.45,102.1)
D3: length 46.4
  TOP w0.2: v2(22.2,101.65) 22.2,102.05 21.45,102.81 21.45,111.86 23.68,114.1 24.9,114.1 24.91,114.09 U8.30 ; U9.41 26.67,102.58 v2(26.8,102.45)
  INNER1 w0.2: v2(26.8,102.45) 24.66,102.45 23.7,101.5 23.2,101.5 23.04,101.65 v2(22.2,101.65)
  INNER2 w0.2: J6.E11 9.66,102.37 11.64,104.35 13.25,104.35 14.13,103.47 16.23,103.47 16.44,103.68 18.23,103.68 18.9,104.35 20.33,104.35 21.88,102.8 23.49,102.8 23.6,102.69 24.21,102.69 24.5,102.4 26.75,102.4 v2(26.8,102.45)
D4: length 58.5
  TOP w0.2: U8.32 26.45,115.09 26.46,115.09 27.26,115.09 27.95,114.4 27.95,112.1 26.95,111.1 23.6,111.1 22.24,109.75 22.24,103.5 22.45,103.3 v2(23.85,103.3) 23.85,103.3 24.35,103.3 24.62,103.58 U9.43
  INNER2 w0.2: v2(23.85,103.3) 21.95,103.3 18.65,106.6 14.3,106.6 13.07,105.38 12.12,105.38 11.6,105.9 10.29,105.9 9.3,104.91 J6.E12
  BOTTOM w0.2: v2(23.85,103.3) 23.45,103.3 22.8,102.65 22.8,101.91 22.8,101.9 22.8,101.4 22.8,101.39 22.8,100 23.85,98.95 v2(23.85,88.65)
D5: length 42
  TOP w0.2: U8.33 26.52,115.59 26.62,115.49 27.51,115.49 28.35,114.65 28.35,111.93 27.12,110.7 23.77,110.7 22.64,109.58 22.64,104.4 22.99,104.05 24.05,104.05 v2(24.07,104.08) U9.44
  INNER2 w0.2: J6.E13 9.37,107.45 9.57,107.25 9.57,107.25 10.22,106.6 11.45,106.6 12.3,107.45 19.2,107.45 22.55,104.1 24.05,104.1 v2(24.07,104.08)
D6: length 36.8
  TOP w0.2: U9.46 25.49,105.05 23.3,105.05 v2(23.25,105.1) ; v2(23.3,116.5) 23.58,116.5 23.7,116.39 24.2,116.39 24.41,116.6 25.64,116.6 U8.35
  INNER2 w0.2: v2(23.25,105.1) 19.03,109.31 11.91,109.31 11.7,109.1 10.3,109.1 9.41,109.99 J6.E14
  BOTTOM w0.2: v2(23.25,105.1) 23.25,116.45 v2(23.3,116.5)
D7: length 36.9
  TOP w0.2: U8.36 25.64,117.1 24.06,117.1 23.95,116.99 v2(23.95,116.99) ; U9.47 25.49,105.6 24.1,105.6 v2(24.05,105.66)
  INNER2 w0.2: v2(24.05,105.66) 19.4,110.3 12.35,110.3 11.5,111.15 10.5,111.15 9.12,112.53 J6.E15
  BOTTOM w0.2: v2(24.05,105.66) 23.7,106.01 23.7,115.9 23.95,116.15 v2(23.95,116.99)
D8: length 30.3
  TOP w0.2: U6.47 24.8,139.36 24.35,139.81 24.35,141.26 24.35,141.26 24.35,141.28 22.38,143.25 22.36,143.25 21.7,143.91 15.53,143.91 14.23,142.62 6.56,142.62 4.87,140.92 J6.E24
D9: length 32.6
  TOP w0.2: U6.46 24.8,138.86 24.75,138.91 24.68,138.91 23.95,139.64 23.95,141.09 23.95,141.1 23.95,141.11 22.21,142.86 22.19,142.86 21.54,143.51 15.69,143.51 14.4,142.22 6.76,142.22 5.45,140.9 5.45,136.6 5.72,136.33 5.72,134.73 4.87,133.88 J6.E23
D10: length 34.1
  TOP w0.2: J6.E22 5.72,131.16 5.72,134.05 5.77,134.1 5.77,134.22 7.07,135.52 7.07,137.42 7.45,137.8 7.45,141.05 8.21,141.81 14.57,141.81 15.86,143.11 21.37,143.11 22.02,142.45 22.04,142.45 23.55,140.95 23.55,140.93 23.55,140.93 23.55,139.11 24.8,137.86 U6.44
D11: length 35.6
  TOP w0.2: U6.43 24.7,137.36 23.15,138.91 23.15,139.44 23.15,139.44 23.15,140.76 23.15,140.76 23.15,140.78 21.88,142.06 21.86,142.06 21.21,142.71 16.02,142.71 11.37,138.06 8.43,138.06 7.47,137.09 7.47,128.12 7,127.65 4.99,127.65 J6.E21
D12: length 38.1
  TOP w0.2: U6.41 24.73,136.36 22.75,138.34 22.75,139.6 22.75,139.6 22.75,140.6 22.75,140.6 22.75,140.62 21.71,141.66 21.69,141.66 21.04,142.31 16.19,142.31 11.54,137.66 8.6,137.66 7.87,136.92 7.87,125.95 7.15,125.23 J6.E20
D13: length 40.3
  TOP w0.2: U6.40 24.66,135.86 22.35,138.17 22.35,139.77 22.35,139.77 22.35,140.43 20.88,141.91 16.36,141.91 11.7,137.25 8.76,137.25 8.27,136.76 8.27,123.77 7.05,122.55 5.01,122.55 J6.E19
D14: length 33.7
  TOP w0.2: v2(24.15,135.42) 24.37,135.2 24.4,135.2 24.75,134.86 U6.38
  INNER1 w0.2: J6.E18 7,120.15 7.75,120.9 7.75,131.73 10.18,134.16 11.14,134.16 12.13,135.15 23.88,135.15 v2(24.15,135.42)
D15: length 35.8
  TOP w0.2: v2(24.15,134.6) 24.39,134.36 U6.37
  INNER1 w0.2: v2(24.15,134.6) 24.04,134.72 12.26,134.72 11.3,133.76 10.34,133.76 8.15,131.56 8.15,118.35 7.41,117.61 J6.E17
D+: length 78.1
  TOP w0.102: v1(61.27,91.17) U2.N11
  INNER1 w0.127: v2(115.25,113.19) 114.97,113.47 114.48,113.47 114.3,113.29 114.3,107.88 114.45,107.72 114.45,107.33 v2(114.73,107.05)
  BOTTOM w0.102: 67.94,90.3 67.92,90.3 67.91,90.31 67.27,90.31 67.25,90.32 62.75,90.32 62.33,90.75 61.72,90.75 61.3,91.17 v1(61.27,91.17)
  BOTTOM w0.127: 67.94,90.3 79.17,90.3 84.9,96.02 84.9,96.23 84.9,96.23 84.9,96.34 84.9,96.34 84.9,106.44 85.07,106.62 112.54,106.62 112.89,106.26 114.18,106.26 114.45,106.54 114.45,106.77 v2(114.73,107.05) ; C2001.1 114.47,113.19 v2(115.25,113.19) 115.91,113.19 R2000.2
D-: length 77
  TOP w0.102: v1(62.25,91.15) 61.85,90.75 61.75,90.65 U2.P11
  INNER1 w0.127: v2(113.92,107.05) 114.2,107.33 114.2,107.62 114.05,107.77 114.05,113.4 114.37,113.72 114.97,113.72 v2(115.25,114)
  BOTTOM w0.102: 67.94,90.55 62.85,90.55 v1(62.25,91.15)
  BOTTOM w0.127: v2(113.92,107.05) 114.2,106.77 114.2,106.65 114.07,106.52 113,106.52 112.65,106.87 84.97,106.87 84.65,106.55 84.65,96.45 84.64,96.44 84.64,96.12 79.07,90.55 67.94,90.55 ; R2001.2 115.84,114 v2(115.25,114) 114.54,114 C2000.1
DATA0+: length 27.3
  TOP w0.102: U1.B6 v1(49.9,120.2) ; U2.B5 v1(55.25,103.15)
  INNER1 w0.102: 49.48,118.74 49.48,119.33 49.9,119.75 v1(49.9,120.2) ; v1(55.25,103.15) 55.25,103.61 54.85,104.01 54.85,104.67
  INNER1 w0.127: 54.85,104.67 54.85,109.71 54.19,110.38 52.47,110.38 51.4,111.45 51.4,112.72 52,112.72 52,112.97 51.3,112.97 51.3,113.81 52,113.81 52,114.21 51.4,114.21 51.4,115.04 52,115.04 52,115.37 51.4,115.37 51.4,116.21 52,116.21 52,116.53 51.4,116.53 51.4,117.34 50.49,118.25 49.97,118.25 49.48,118.74
DATA0-: length 24.9
  TOP w0.102: U2.A5 v1(55.25,104.15) ; U1.A6 v1(49.9,119.2)
  INNER1 w0.102: 55.1,104.67 55.1,104.66 55.09,104.64 55.09,104.57 55.08,104.56 55.08,104.32 v1(55.25,104.15) ; 49.95,118.74 49.9,118.78 v1(49.9,119.2)
  INNER1 w0.127: 55.1,104.67 55.1,109.82 54.29,110.63 52.58,110.63 51.65,111.56 51.65,112.47 52.25,112.47 52.25,113.23 51.55,113.23 51.55,113.56 52.25,113.56 52.25,114.46 51.65,114.46 51.65,114.79 52.25,114.79 52.25,115.62 51.65,115.62 51.65,115.95 52.25,115.95 52.25,116.79 51.65,116.79 51.65,117.45 50.6,118.5 50.19,118.5 49.95,118.74
DATA1+: length 27.2
  TOP w0.102: U1.D6 v1(49.9,122.2) ; U2.D5 v1(55.25,101.15)
  INNER1 w0.102: 48.9,118.74 48.9,119.52 49.28,119.9 49.28,121.18 49.9,121.8 v1(49.9,122.2) ; 54.27,104.67 54.27,104.56 54.3,104.53 54.3,103.64 54.64,103.3 54.64,102.44 54.87,102.21 54.87,101.99 55.25,101.61 v1(55.25,101.15)
  INNER1 w0.127: 48.9,118.74 48.9,118.3 49.06,118.13 49.06,118.09 49.5,117.65 50.12,117.65 50.25,117.52 50.25,111.29 51.74,109.8 53.94,109.8 54.27,109.47 54.27,104.67
DATA1-: length 24.9
  TOP w0.102: U1.C6 v1(49.9,121.2) ; U2.C5 v1(55.25,102.15)
  INNER1 w0.102: v1(55.25,102.15) 54.87,102.53 54.87,103.39 54.53,103.73 54.53,104.66 54.52,104.67 ; 49.15,118.74 49.15,119.45 49.51,119.81 49.51,120.81 v1(49.9,121.2)
  INNER1 w0.127: 49.15,118.74 49.15,118.4 49.32,118.24 49.32,118.19 49.61,117.9 50.22,117.9 50.5,117.62 50.5,111.4 51.85,110.05 54.05,110.05 54.52,109.58 54.52,104.67
DATA1.CLKA: length 156.1
  TOP w0.102: U1.K5 v1(50.9,129.2)
  TOP w0.2: 84.57,61.51 85.3,60.78 85.3,50.15 84.25,49.1 81.15,49.1 80.17,50.08 U38.11 ; 84.57,61.51 84.57,76.33 83.91,76.99 82.73,76.99 v2(82.73,77.92) ; 84.57,61.51 82.73,61.51
  INNER1 w0.102: 55.59,129 55.42,129 55.24,128.82 53.06,128.82 53.06,128.82 51.74,128.82 51.74,128.82 51.28,128.82 v1(50.9,129.2)
  INNER1 w0.2: 55.59,129 59.8,129 60.74,128.06 62.09,128.06 62.9,127.25 62.95,127.2 63.45,127.2 63.5,127.25 69.75,127.25 71.7,125.3 71.7,124.74 75.54,120.9 97.53,120.9 102.25,116.18 102.25,106.42 101.3,105.47 101.3,96.2 103.66,93.85 103.66,84.9 104.25,84.3 104.25,81.61 101.8,79.15 90.25,79.15 89.02,77.92 v2(82.73,77.92)
DATA1.VD0: length 86.6
  TOP w0.102: U1.M2 v1(53.9,131.2)
  INNER1 w0.102: v1(53.9,131.2) 54.4,131.7 55.59,131.7
  INNER1 w0.2: 55.59,131.7 55.75,131.7 55.9,131.55 70.97,131.55 72.9,129.62 72.9,125.24 76.04,122.1 98.09,122.1 103.45,116.74 103.45,98.9 102.9,98.34 102.9,96.35 105.2,94.04 v2(105.2,92.6)
  BOTTOM w0.2: RN3.1 104.25,91.44 104.25,92.4 104.45,92.6 v2(105.2,92.6)
DATA1.VD1: length 85.6
  TOP w0.102: U1.M1 v1(54.9,131.2)
  INNER1 w0.102: 55.59,131.15 54.95,131.15 v1(54.9,131.2)
  INNER1 w0.2: v2(105.4,91.6) 105.24,91.76 105.16,91.76 104.59,92.32 104.59,94.04 102.1,96.53 102.1,105.12 103.05,106.07 103.05,116.52 97.87,121.7 75.87,121.7 72.5,125.07 72.5,129.45 70.8,131.15 55.59,131.15
  BOTTOM w0.2: RN3.2 104.8,91 v2(105.4,91.6)
DATA1.VD2: length 89.3
  TOP w0.102: U1.N3 v1(52.9,132.2)
  INNER1 w0.102: 55.59,130.75 55.54,130.8 53.55,130.8 53.35,131 53.35,131.75 v1(52.9,132.2)
  INNER1 w0.2: 55.59,130.75 70.63,130.75 72.1,129.28 72.1,124.9 75.7,121.3 97.7,121.3 102.65,116.35 102.65,106.25 101.7,105.3 101.7,96.37 104.19,93.87 104.19,91.96 104.79,91.36 104.79,91.35 105.15,91 105.16,91 105.35,90.81 v2(105.69,90.81)
  BOTTOM w0.2: v2(105.69,90.81) 105.48,90.6 RN3.3
DATA1.VD3: length 89.6
  TOP w0.102: U1.N1 v1(54.9,132.2)
  INNER1 w0.102: v1(54.9,132.2) 55.59,132.2
  INNER1 w0.2: 55.59,132.2 55.92,132.2 56.17,131.95 71.13,131.95 73.3,129.78 73.3,125.4 76.2,122.5 98.25,122.5 103.85,116.9 103.85,98.9 105.85,96.9 105.85,92.22 106.85,91.22 106.85,90.2 106.25,89.6 v2(105.1,89.6)
  BOTTOM w0.2: v2(105.1,89.6) 104.5,90.2 RN3.4
DATA1.VD4: length 93.9
  TOP w0.102: U1.P2 v1(53.9,133.2)
  INNER1 w0.102: 55.59,132.71 55.55,132.75 54.35,132.75 v1(53.9,133.2)
  INNER1 w0.2: v2(105.28,86.73) 105.28,86.98 107.25,88.95 107.25,91.38 106.25,92.38 106.25,97.07 104.25,99.07 104.25,117.07 98.42,122.9 76.37,122.9 73.7,125.57 73.7,129.95 71.3,132.35 56.33,132.35 55.97,132.71 55.59,132.71
  BOTTOM w0.2: RN2.1 104.46,86.32 104.84,86.7 105.25,86.7 v2(105.28,86.73)
DATA1.VD5: length 94.4
  TOP w0.102: U1.P1 v1(54.9,133.2)
  INNER1 w0.102: v1(54.9,133.2) 55.59,133.2
  INNER1 w0.2: v2(106,86.33) 106,87.14 107.65,88.78 107.65,91.6 106.65,92.6 106.65,97.23 104.65,99.23 104.65,117.23 98.58,123.3 76.53,123.3 74.1,125.73 74.1,130.15 71.5,132.75 56.5,132.75 56.05,133.2 55.59,133.2
  BOTTOM w0.15: RN2.2 104.72,85.92 104.8,86 105.67,86 v2(106,86.33)
DATA1.VD6: length 98.9
  TOP w0.102: U1.R2 v1(53.9,134.2)
  INNER1 w0.2: v2(107.32,86) 108.45,87.13 108.45,91.97 107.5,92.92 107.5,97.55 105.45,99.6 105.45,117.6 98.95,124.1 76.9,124.1 74.9,126.1 74.9,130.55 72.5,132.95 v2(72.5,133.55)
  INNER2 w0.1: 55.59,133.41 55.3,133.7 54.4,133.7 v1(53.9,134.2)
  INNER2 w0.2: v2(72.5,133.55) 72.15,133.2 55.8,133.2 55.59,133.41
  BOTTOM w0.2: RN2.3 104.85,85.52 104.96,85.62 106.94,85.62 v2(107.32,86)
DATA1.VD7: length 96.6
  TOP w0.102: U1.R1 v1(54.9,134.2)
  INNER1 w0.102: v1(54.9,134.2) 55.59,134.2
  INNER1 w0.2: v2(105.3,85) 105.83,85 106.72,85.88 106.72,87.27 108.05,88.6 108.05,91.8 107.05,92.8 107.05,97.4 105.05,99.4 105.05,117.4 98.75,123.7 76.7,123.7 74.5,125.9 74.5,130.35 71.7,133.15 56.75,133.15 55.7,134.2 55.59,134.2
  BOTTOM w0.2: RN2.4 105.18,85.12 v2(105.3,85)
DATA1.WSTAT_L: length 99.2
  TOP w0.102: U1.J6 v1(49.9,128.2)
  TOP w0.2: U22.11 103.28,82.39 v2(103.25,82.35)
  INNER1 w0.102: 55.59,127.55 50.55,127.55 v1(49.9,128.2)
  INNER1 w0.2: v2(103.25,82.35) 102.85,82.75 102.85,93.4 102.19,94.06 102.19,94.07 101.83,94.42 100.5,95.75 100.5,106 101.41,106.91 101.41,115.9 97.2,120.1 75.21,120.1 70.9,124.41 70.9,124.97 69.42,126.45 63.83,126.45 63.78,126.4 62.62,126.4 62.57,126.45 60.25,126.45 59.15,127.55 55.59,127.55
DATA2+: length 27.3
  TOP w0.102: U1.B5 v1(50.9,120.2) ; U2.D6 v1(56.25,101.15)
  INNER1 w0.102: v1(56.25,101.15) 56.25,101.45 55.64,102.06 55.64,104.55 55.62,104.56 55.62,104.67
  INNER1 w0.127: v1(50.9,120.2) 50.9,119.75 50.74,119.59 50.74,119.59 50.51,119.36 50.51,119.36 50.45,119.3 50.45,119.05 50.69,118.81 51.23,118.81 52.6,117.44 52.6,115.71 53.15,115.71 53.15,115.38 52.6,115.38 52.6,114.55 53.15,114.55 53.15,114.22 52.6,114.22 52.6,113.39 53.15,113.39 53.15,113.06 52.6,113.06 52.6,111.8 53.15,111.25 54.23,111.25 55.43,110.05 55.43,107.87 55.62,107.68 55.62,104.67
DATA2-: length 24.8
  TOP w0.102: U2.C6 v1(56.25,102.15) ; U1.A5 v1(50.9,119.2)
  INNER1 w0.102: v1(56.25,102.15) 56.25,102.16 55.87,102.54 55.87,104.66 55.88,104.67
  INNER1 w0.127: 55.88,104.67 55.88,107.82 55.69,108.02 55.69,110.16 54.34,111.5 53.26,111.5 52.85,111.91 52.85,112.81 53.4,112.81 53.4,113.64 52.85,113.64 52.85,113.97 53.4,113.97 53.4,114.8 52.85,114.8 52.85,115.13 53.4,115.13 53.4,115.97 52.85,115.97 52.85,117.55 51.2,119.2 v1(50.9,119.2)
DATA3+: length 27
  TOP w0.102: U1.D5 v1(50.9,122.2) ; U2.B6 v1(56.25,103.15)
  INNER1 w0.102: 53.22,118.92 53.2,118.94 53.19,118.94 52.3,119.82 51.74,119.82 51.52,120.04 51.52,121.18 50.9,121.8 v1(50.9,122.2) ; v1(56.25,103.15) 56.25,103.6 56.68,104.03 56.68,104.37
  INNER1 w0.127: 53.22,118.92 54,118.14 54,112.76 54.65,112.11 55.3,112.75 55.89,112.16 55.25,111.51 55.48,111.28 56.12,111.93 56.72,111.33 56.07,110.69 56.5,110.26 56.5,104.55 56.68,104.37
DATA3-: length 24.7
  TOP w0.102: U2.A6 v1(56.25,104.15) ; U1.C5 v1(50.9,121.2)
  INNER1 w0.102: 53.04,118.74 53.02,118.76 53.02,118.78 52.21,119.59 51.65,119.59 51.29,119.95 51.29,120.81 v1(50.9,121.2) ; 56.25,104.67 56.25,104.67 v1(56.25,104.15)
  INNER1 w0.127: 53.04,118.74 53.75,118.03 53.75,112.65 54.65,111.75 55.3,112.39 55.53,112.16 54.89,111.51 55.48,110.92 56.12,111.56 56.36,111.33 55.71,110.69 56.25,110.15 56.25,105.8 56.25,105.8 56.25,104.67
DATA.BA0: length 66
  TOP w0.102: U1.H16 v1(38.9,126.2)
  TOP w0.2: U8.2 18.84,122.59 19.1,122.85 19.1,123.7 18.8,124 v2(18,124) ; v2(16.6,100.1) 17.89,100.1 U9.13 ; U6.13 18.98,133.86 20.95,131.88 v2(20.95,131.35)
  INNER1 w0.102: v1(38.9,126.2) 38.32,126.2
  INNER1 w0.2: v2(18,124) 18,125.15 18.84,126 38.11,126 38.32,126.2
  INNER2 w0.2: v2(18,124) 18,130 19.35,131.35 v2(20.95,131.35)
  BOTTOM w0.2: v2(18,124) 18,106.7 17.3,106 17.3,100.8 v2(16.6,100.1)
DATA.BA1: length 63.9
  TOP w0.102: U1.H15 v1(39.9,126.2)
  TOP w0.2: v2(19.35,99.8) 19.25,99.8 19.02,99.58 U9.14 ; U8.3 19.04,122.09 v2(20.05,123.1) 20.05,124.83 20.3,125.09 20.3,131.96 18.91,133.36 U6.14
  INNER1 w0.102: 38.32,125.63 38.5,125.82 39.06,125.82 39.44,126.2 v1(39.9,126.2)
  INNER1 w0.2: v2(20.05,123.1) 20.1,123.15 20.1,124.9 20.79,125.59 38.28,125.59 38.32,125.63
  BOTTOM w0.2: v2(20.05,123.1) 21.25,121.9 21.25,100.6 20.45,99.8 v2(19.35,99.8)
DATA.BA2: length 66.4
  TOP w0.102: U1.G14 v1(40.9,125.2)
  TOP w0.2: U9.16 18.72,98.58 19,98.85 19.4,98.85 20.05,99.5 20.05,101.05 v2(20.6,101.6) ; v2(20.05,121.35) 19.29,121.35 19.04,121.09 U8.5 17.17,121.09 17.06,120.99 16.56,120.99 16.1,121.45 16.1,132.2 16.3,132.41 17,132.41 17.01,132.4 18,132.4 U6.16
  INNER1 w0.102: 38.32,124.8 40.03,124.8 40.44,125.2 v1(40.9,125.2)
  INNER1 w0.2: v2(20.05,121.35) 21.05,122.36 21.05,124.29 21.56,124.8 38.32,124.8
  BOTTOM w0.2: v2(20.6,101.6) 20.85,101.85 20.85,120.55 v2(20.05,121.35)
DATA.BA3: length 63.1
  TOP w0.102: U1.G16 v1(38.9,125.2)
  TOP w0.2: U8.6 18.05,120.6 v2(19.4,120.6) ; U6.17 18.89,131.86 19.9,130.84 19.9,125.26 v2(19.4,124.75) ; v2(19.2,98.05) 17.94,98.05 U9.17
  INNER1 w0.102: v1(38.9,125.2) 38.45,125.2 38.44,125.2 38.32,125.2
  INNER1 w0.2: 38.32,125.2 21.39,125.2 20.65,124.45 20.65,123.36 20.65,123.35 20.65,122.81 19.8,121.95 19.8,121.95 19.45,121.6 19.45,120.64 v2(19.4,120.6)
  BOTTOM w0.2: v2(19.2,98.05) 18.74,98.5 18.74,100.05 19.1,100.41 19.35,100.41 19.99,101.05 19.99,101.9 20.45,102.35 20.45,119.6 19.45,120.6 v2(19.4,120.6) v2(19.4,124.75)
DATA.BD0: length 33.6
  TOP w0.102: U1.F16 v1(38.9,124.2)
  TOP w0.2: U9.2 v2(16.57,105.58)
  INNER1 w0.102: v1(38.9,124.2) 38.65,123.95 38.32,123.95
  INNER1 w0.2: 38.32,123.95 37,123.95 34,120.95 34,118.36 25.14,109.5 22.69,109.5 19.27,106.08 18.71,106.08 18.2,105.58 v2(16.57,105.58)
DATA.BD1: length 33
  TOP w0.102: U1.F15 v1(39.9,124.2)
  TOP w0.2: U9.3 v2(19.12,105.08)
  INNER1 w0.102: 38.32,122.7 38.42,122.8 39.15,122.8 39.4,123.05 39.4,123.7 v1(39.9,124.2)
  INNER1 w0.2: 38.32,122.7 36.92,122.7 34.8,120.58 34.8,118.03 25.47,108.7 23.02,108.7 20.5,106.18 20.5,105.37 20.21,105.08 v2(19.12,105.08)
DATA.BD2: length 35.2
  TOP w0.102: U1.E16 v1(38.9,123.2)
  TOP w0.2: v2(15.97,104.08) 16.33,104.08 16.44,103.97 16.94,103.97 17.04,104.08 U9.5
  INNER1 w0.102: 38.32,123.2 v1(38.9,123.2)
  INNER1 w0.2: v2(15.97,104.08) 16.33,104.08 16.44,103.97 17.16,103.97 18.87,105.68 19.43,105.68 22.85,109.1 25.3,109.1 34.4,118.2 34.4,120.75 36.85,123.2 38.32,123.2
DATA.BD3: length 33.3
  TOP w0.102: U1.E15 v1(39.9,123.2)
  TOP w0.2: U9.6 19.02,103.58 v2(19.15,103.7)
  INNER1 w0.102: 38.32,122.3 38.46,122.3 38.74,122.58 39.28,122.58 v1(39.9,123.2)
  INNER1 w0.2: v2(19.15,103.7) 20.25,103.7 20.9,104.35 20.9,106.01 23.19,108.3 25.64,108.3 35.2,117.86 35.2,120.42 37.08,122.3 38.32,122.3
DATA.BD4: length 40.7
  TOP w0.102: U1.E13 v1(41.9,123.2)
  TOP w0.2: U9.8 17.04,102.58 16.94,102.47 16.18,102.47 v2(15.95,102.7)
  INNER1 w0.102: v1(41.9,123.2) 41.52,123.58 40.74,123.58 40.35,123.19 40.35,122.8 40.25,122.7 39.66,122.7 39.28,122.32 39.28,122.04 39.06,121.82 38.4,121.82 38.32,121.9
  INNER1 w0.2: 38.32,121.9 37.25,121.9 35.6,120.25 35.6,117.7 25.8,107.9 23.35,107.9 21.3,105.85 21.3,104.1 20.28,103.08 18.66,103.08 18.05,102.47 16.18,102.47 v2(15.95,102.7)
DATA.BD5: length 37.5
  TOP w0.102: U1.E12 v1(42.9,123.2)
  TOP w0.2: U9.9 v2(19.07,102.08)
  INNER1 w0.102: v1(42.9,123.2) 42.28,122.58 41.74,122.58 41.52,122.36 41.52,121.87 41.23,121.58 40.74,121.58 40.52,121.36 40.52,120.87 40.23,120.58 39.74,120.58 39.52,120.36 39.52,120.28 39.06,119.82 38.38,119.82 38.32,119.75
  INNER1 w0.2: v2(19.07,102.08) 19.28,102.28 21.25,102.28 22.1,103.13 22.1,105.52 23.68,107.1 26.13,107.1 36.4,117.37 36.4,119.08 37.07,119.75 38.32,119.75
DATA.BD6: length 33.6
  TOP w0.102: U1.B15 v1(39.9,120.2)
  TOP w0.2: U9.11 v2(19.07,101.08)
  INNER1 w0.102: 39.45,119.76 39.53,119.84 39.55,119.84 v1(39.9,120.2)
  INNER1 w0.2: 39.45,119.76 39.45,119.14 39.08,118.77 37,118.77 36.8,118.57 36.8,117.2 26.3,106.7 23.85,106.7 22.64,105.5 22.64,103 21.55,101.9 21.55,101.4 21.1,100.95 20.25,100.95 20.12,101.08 v2(19.07,101.08)
DATA.BD7: length 36
  TOP w0.102: U1.B16 v1(38.9,120.2)
  TOP w0.2: v2(16.05,100.75) 16.8,100.75 16.97,100.58 U9.12
  INNER1 w0.102: v1(38.9,120.2) 38.4,120.2 38.35,120.15
  INNER1 w0.2: v2(16.05,100.75) 16.89,100.75 18.82,102.68 21.08,102.68 21.7,103.3 21.7,105.68 23.52,107.5 25.97,107.5 36,117.53 36,119.25 36.9,120.15 38.35,120.15
DATA.BD8: length 64.6
  TOP w0.102: U1.F12 v1(42.9,124.2)
  TOP w0.2: U8.23 15.46,112.09 13.85,113.7 13.85,113.78 13.8,113.83 13.8,125.25 v2(14.25,125.7) 14.04,125.91 14.04,127.2 14.5,127.66 14.5,137.15 16.7,139.35 18.04,139.35 U6.2
  INNER1 w0.102: v1(42.9,124.2) 42.9,124.74 40.64,127 38.32,127
  INNER1 w0.2: v2(14.25,125.7) 16.69,125.7 17.99,127 38.32,127
DATA.BD9: length 62.9
  TOP w0.102: U1.G11 v1(43.9,125.2)
  TOP w0.2: U8.22 15.61,112.59 14.2,114 14.2,124.45 14.44,124.7 14.44,124.7 14.9,125.16 14.9,126.7 v2(14.65,126.95) 14.9,127.2 14.9,136.86 16.14,138.1 16.15,138.1 16.9,138.85 18.04,138.85 U6.3
  INNER1 w0.102: 38.32,127.4 40.5,127.4 42.7,125.2 v1(43.9,125.2)
  INNER1 w0.2: 38.32,127.4 17.82,127.4 17.32,126.89 14.7,126.89 v2(14.65,126.95)
DATA.BD12: length 56.3
  TOP w0.102: U1.F13 v1(41.9,124.2)
  TOP w0.2: U6.8 16.6,136.36 15.3,135.06 15.3,124.7 v2(15.05,124.45) 14.65,124.05 14.65,116.2 15.76,115.09 17.23,115.09 17.24,115.09 U8.17
  INNER1 w0.102: v1(41.9,124.2) 41.9,124.66 41.52,125.04 41.52,125.45 40.22,126.75 38.47,126.75 38.32,126.6
  INNER1 w0.2: 38.32,126.6 18.15,126.6 16,124.45 v2(15.05,124.45)
DATA.BD13: length 55.4
  TOP w0.102: U1.F14 v1(40.9,124.2)
  TOP w0.2: U8.16 17.17,115.59 17.06,115.49 16.01,115.49 15.45,116.05 v2(15.45,118.25) 15.45,119.4 15.7,119.65 15.7,134.86 16.7,135.86 U6.9
  INNER1 w0.102: v1(40.9,124.2) 40.44,124.2 40.06,124.58 38.67,124.58 38.48,124.39 38.32,124.39
  INNER1 w0.2: 38.32,124.39 22.04,124.39 21.49,123.84 21.49,121.85 19.9,120.26 19.9,119.37 19.9,119.36 19.9,119.34 19.54,118.99 19.52,118.99 18.48,117.95 15.75,117.95 v2(15.45,118.25)
DATA.BD14: length 45
  TOP w0.102: U1.C15 v1(39.9,121.2)
  TOP w0.2: U6.11 19.14,134.86 21.95,132.05 21.95,120.7 23,119.65 23,118.55 v2(22.45,118) 21.04,116.59 U8.14
  INNER2 w0.102: v1(39.9,121.2) 39.44,121.2 38.99,120.75 38.7,120.75
  INNER2 w0.2: v2(22.45,118) 23.1,118.65 23.1,119.05 23.8,119.75 25.74,119.75 27.34,121.35 38.15,121.35 38.5,121 38.5,120.95 38.7,120.75
DATA.BD15: length 41.6
  TOP w0.102: U1.C16 v1(38.9,121.2)
  TOP w0.2: U6.12 19.04,134.36 21.55,131.84 21.55,120.4 22.25,119.7 v2(22.25,118.85) 20.49,117.09 U8.13
  INNER2 w0.2: v1(38.9,121.2) 38.35,121.75 27.51,121.75 27.51,121.75 27.18,121.75 25.57,120.15 23.55,120.15 v2(22.25,118.85)
DATA.CLKB: length 41.5
  TOP w0.1: 38.32,127.7 U1.J16
  TOP w0.2: 38.32,127.7 37.75,127.7 v2(33.75,123.7)
  INNER1 w0.2: J6.E16 9.67,115.07 10.02,115.42 10.02,115.42 10.51,115.92 10.52,115.92 12.1,117.5 18.6,117.5 19.69,118.59 19.71,118.59 20.3,119.18 20.3,119.2 20.3,119.2 20.3,120.09 21.89,121.68 21.89,123.44 22.4,123.95 33.5,123.95 v2(33.75,123.7)
DDIR: length 63.7
  TOP w0.2: U8.24 18.09,111.55 v2(19.25,111.55) 19.25,106.45 18.88,106.08 U9.1 ; U6.1 18.78,139.86 18.78,139.85 19.1,139.85 v2(19.4,139.55) ; U7.1 v2(18.02,87.88)
  BOTTOM w0.2: v2(19.4,139.55) 18.65,138.81 18.65,112.43 18.65,112.43 18.65,112.15 v2(19.25,111.55) 19.25,107.25 17.7,105.7 17.7,88.2 v2(18.02,87.88)
DDR_A0: length 37.7
  TOP w0.102: U12.M8 v1(34.3,103.3) 33.85,102.85 33.85,101.9 34.8,100.95 43.1,100.95 44.65,102.5 50.9,102.5 U2.C1 ; U13.M8 v1(34.3,89.5)
  INNER2 w0.102: v1(34.3,89.5) 35,90.2 35,90.65 35.48,91.13 35.48,95.26 35.24,95.5 34.85,95.5 33.5,96.85 33.5,102.37 34.1,102.97 34.1,103.1 v1(34.3,103.3)
DDR_A1: length 38.3
  TOP w0.102: U12.M3 v1(34.3,108.1) ; U2.D1 v1(51.25,101.15) ; U13.M3 v1(34.3,94.3)
  INNER1 w0.102: v1(34.3,94.3) 33.88,94.72 33.88,107.68 v1(34.3,108.1)
  INNER2 w0.102: v1(34.3,108.1) 34.3,106.75 35.55,105.5 37.25,105.5 37.9,104.85 37.9,102 38.75,101.15 v1(51.25,101.15)
DDR_A2: length 35.8
  TOP w0.102: U2.E1 v1(51.25,100.15) ; v1(34.3,104.1) U12.M7 35.2,105 v1(36.7,105) ; U13.M7 34.3,91.1 v1(34.3,91.6)
  INNER2 w0.102: v1(34.3,91.6) 33.92,91.98 33.92,96.13 33.3,96.75 33.3,102.43 33.92,103.05 33.92,103.46 34.3,103.84 v1(34.3,104.1) ; v1(36.7,105) 37,105 37.72,104.28 37.72,101.92 38.67,100.97 50.43,100.97 v1(51.25,100.15)
DDR_A3: length 39.3
  TOP w0.102: U12.N2 v1(33.5,108.9) ; U2.F1 51.75,98.25 52.11,97.9 52.11,97.46 51.75,97.1 33.8,97.1 33.1,96.4 33.1,95.5 v1(33.5,95.1) U13.N2
  BOTTOM w0.102: v1(33.5,95.1) 33.1,95.5 33.1,96.3 33.34,96.54 33.34,102.92 33.1,103.16 33.1,104.4 33.5,104.8 34.5,104.8 34.75,105.05 34.75,107.1 33.88,107.97 33.88,108.52 v1(33.5,108.9)
DDR_A4: length 36.8
  TOP w0.102: U2.G1 50.5,97.65 50,98.15 44.95,98.15 42.4,100.7 34.45,100.7 33.5,101.65 v1(33.5,103.3) U12.N8 ; U13.N8 v1(33.5,89.5)
  BOTTOM w0.102: v1(33.5,89.5) 33.5,91.7 33.9,92.1 33.9,102.9 v1(33.5,103.3)
DDR_A5: length 34.5
  TOP w0.102: v1(33.5,94.3) U13.N3 34.26,93.54 44.99,93.54 46.65,95.2 49.6,95.2 51.05,96.65 U2.H1 ; U12.N3 v1(33.5,108.1)
  INNER1 w0.102: v1(33.5,108.1) 33.12,107.72 33.12,94.68 v1(33.5,94.3)
DDR_A6: length 34.8
  TOP w0.102: U12.N7 v1(33.5,104.1) ; U2.J1 50.7,95.65 50.05,95 50.05,93.75 49.6,93.3 46.15,93.3 45.5,92.65 33.9,92.65 v1(33.5,92.25) 33.5,91.1 U13.N7
  INNER2 w0.102: v1(33.5,92.25) 33.5,93.76 33.12,94.14 33.12,103.46 33.5,103.84 v1(33.5,104.1)
DDR_A7: length 44.5
  TOP w0.102: U13.P2 v1(32.7,95.1) ; U12.P2 v1(32.7,108.9) ; U2.K1 v1(51.25,94.15)
  INNER2 w0.1: 37.5,101.8 38.55,100.75 50.1,100.75 51.45,99.4 51.45,96.65 51.25,96.45 v1(51.25,94.15)
  INNER2 w0.102: v1(34.3,105.65) 35.4,104.55 37.1,104.55 37.5,104.15 37.5,101.8
  BOTTOM w0.102: v1(32.7,108.9) 33.08,108.52 33.08,107.62 34.3,106.4 v1(34.3,105.65) 34.3,105.2 34.1,105 32.8,105 32.25,104.45 32.25,96.45 32.7,96 v1(32.7,95.1)
DDR_A8: length 37.1
  TOP w0.102: U2.L1 50.9,93.65 49.65,92.4 34.95,92.4 34.7,92.15 34.7,91.7 35.1,91.3 35.1,90.55 34.85,90.3 33.5,90.3 U13.P8 v1(32.7,89.5) ; U12.P8 v1(32.7,103.3)
  BOTTOM w0.102: v1(32.7,103.3) 33.1,102.9 33.1,96.56 32.92,96.38 32.92,95.42 33.1,95.24 33.1,89.85 32.75,89.5 v1(32.7,89.5)
DDR_A9: length 34.9
  TOP w0.102: v1(44.55,93.05) 39.15,93.05 39.05,93.15 33.85,93.15 U13.P3 v1(32.7,94.3) ; U12.P3 v1(32.7,108.1) ; U2.M1 v1(51.25,92.15)
  INNER1 w0.102: v1(32.7,108.1) 32.32,107.72 32.32,94.68 v1(32.7,94.3)
  INNER2 w0.102: v1(51.25,92.15) 51.15,92.25 45.3,92.25 44.55,93 v1(44.55,93.05)
DDR_A10: length 36.7
  TOP w0.102: U2.N1 51.7,91.65 50.52,90.47 46.33,90.47 44.85,91.95 v1(35.1,91.95) ; U13.M2 v1(34.3,95.1) ; U12.M2 v1(34.3,108.9)
  INNER1 w0.102: v1(35.1,91.95) 34.68,92.37 34.68,94.46 34.3,94.84 v1(34.3,95.1)
  BOTTOM w0.102: v1(34.3,95.1) 34.52,95.32 34.52,96.23 34.7,96.41 34.7,104.5 35,104.8 35,107.2 34.7,107.5 U12.M2 v1(34.3,108.9)
DDR_A11: length 38.7
  TOP w0.102: U2.P1 v1(51.25,90.15) ; U13.P7 32.7,91.1 v1(32.7,91.15) ; U12.P7 v1(32.7,104.1)
  INNER2 w0.102: v1(32.7,91.15) 32.7,93.76 32.32,94.14 32.32,95.27 32.94,95.89 32.94,101.68 32.32,102.3 32.32,103.46 32.7,103.84 v1(32.7,104.1)
  BOTTOM w0.102: v1(32.7,91.15) 32.7,90.04 32.32,89.66 32.32,89.34 32.54,89.12 32.88,89.12 33.1,88.9 33.1,88.55 33.33,88.32 35.13,88.32 35.61,87.84 49.45,87.84 50.87,89.25 50.87,89.31 51.25,89.69 v1(51.25,90.15)
DDR_A12: length 43
  TOP w0.102: U12.R2 v1(31.9,108.9) ; U2.R1 v1(51.25,89.15) ; U13.R2 v1(31.9,95.1)
  INNER2 w0.1: v1(31.9,108.9) 32.14,108.66 32.14,102.22 32.75,101.61 32.75,96 31.9,95.15 v1(31.9,95.1)
  BOTTOM w0.102: v1(31.9,95.1) 32.1,94.9 32.1,88.76 32.72,88.14 35.05,88.14 35.54,87.65 49.53,87.65 51.02,89.15 v1(51.25,89.15)
DDR_BA0: length 34.6
  TOP w0.102: U13.L1 v1(35.1,95.9) ; U12.L2 v1(35.1,108.9) ; U2.M2 v1(52.25,92.15)
  INNER2 w0.1: 51.4,92.53 51.41,92.53 51.79,92.15 v1(52.25,92.15)
  INNER2 w0.102: v1(45.15,93.05) 45.73,92.47 51.03,92.47 51.09,92.53 51.4,92.53
  BOTTOM w0.102: v1(45.15,93.05) 44.65,93.55 39.95,93.55 38.8,94.7 36.3,94.7 v1(35.1,95.9) 35.1,100.45 36.28,101.63 36.28,107.07 35.5,107.85 U12.L2 v1(35.1,108.9)
DDR_BA1: length 41.1
  TOP w0.102: U2.P2 v1(52.25,90.15) ; U13.L3 v1(35.1,94.3) ; U12.L3 v1(35.1,108.1)
  INNER1 w0.102: v1(35.1,94.3) 34.68,94.72 34.68,107.68 v1(35.1,108.1)
  BOTTOM w0.102: v1(52.25,90.15) 52.25,90.6 51.85,91 51.85,91.3 51.62,91.53 50.58,91.53 50.32,91.27 50.32,89.53 49.91,89.12 48.79,89.12 48.75,89.16 48.05,89.16 48.01,89.12 47.79,89.12 47.75,89.16 47.05,89.16 47.01,89.12 35.62,89.12 35.5,89.24 35.5,92.1 35.1,92.5 v1(35.1,94.3)
DDR_BA2: length 58.7
  TOP w0.102: U2.R2 v1(52.25,89.15) ; U13.L2 v1(35.1,95.1) ; U12.L1 v1(35.1,109.7)
  INNER2 w0.102: v1(35.1,95.1) 34.7,94.7 34.7,91.35 34.1,90.75 32.42,90.75 31.25,91.92 31.25,95.1 31.35,95.1 31.8,95.55 32.04,95.55 32.57,96.08 32.57,101.54 31.96,102.15 31.96,108.3 31.52,108.74 31.52,109.07 31.73,109.28 34.68,109.28 v1(35.1,109.7)
  BOTTOM w0.102: v1(35.1,95.1) 34.72,94.72 34.72,89.02 35.72,88.02 49.38,88.02 50.69,89.33 50.69,90.13 51.09,90.53 51.41,90.53 51.63,90.31 51.63,89.67 52.15,89.15 v1(52.25,89.15)
DDR_CAS: length 37.4
  TOP w0.1: U2.T3 52.85,87.75 47.06,87.75 46.27,88.54 46.27,89.28 44.1,91.45 36.25,91.45 v1(35.9,91.1)
  TOP w0.102: U12.L7 v1(35.1,104.1) ; U13.L7 v1(35.9,91.1)
  INNER2 w0.102: v1(35.9,91.1) 36.1,91.3 36.1,93.4 36.28,93.58 36.28,96.27 36.05,96.5 34.45,96.5 33.9,97.05 33.9,101.25 35.18,102.53 35.18,102.68 35.5,103 35.5,103.7 v1(35.1,104.1)
DDR_CK_N: length 40.6
  TOP w0.102: U12.J8 v1(36.7,103.3) ; U2.T5 v1(55.25,88.15) ; U13.J8 v1(36.7,89.5)
  INNER1 w0.102: v1(55.25,88.15) 54,86.9 38.2,86.9 37.1,88 37.1,89.1 v1(36.7,89.5)
  INNER2 w0.1: 37.3,93.9 36.48,93.08 36.48,90.88 36.32,90.71 36.32,89.88 v1(36.7,89.5) ; 36.65,96.45 36.64,96.46 36.64,96.51 36.25,96.9 34.65,96.9 34.3,97.25 34.3,101.05 35.35,102.1 36.15,102.1 36.3,102.25 36.3,102.8 36.7,103.2 v1(36.7,103.3)
  INNER2 w0.102: 37.3,93.9 37.3,94.6 36.65,95.25 36.65,96.45
DDR_CK_P: length 41.1
  TOP w0.102: U13.K8 v1(35.9,89.5) ; U2.R5 v1(55.25,89.15) ; U12.K8 v1(35.9,103.3)
  INNER1 w0.102: v1(35.9,89.5) 36.3,89.1 36.3,87.95 37.55,86.7 54.9,86.7 55.7,87.5 55.7,88.7 v1(55.25,89.15)
  BOTTOM w0.102: v1(35.9,89.5) 36.28,89.88 36.28,91.77 35.5,92.55 35.5,95.2 35.48,95.22 35.48,95.26 35.24,95.5 34.85,95.5 34.7,95.65 34.7,96.15 34.9,96.35 34.9,100.55 35.7,101.35 35.7,102.16 35.52,102.34 35.52,102.92 v1(35.9,103.3)
DDR_CKE: length 43.4
  TOP w0.102: U2.T4 v1(54.25,88.15) ; U12.K2 v1(35.9,108.9) ; U13.K2 35.9,95.1 v1(35.9,95.9)
  INNER1 w0.102: v1(35.9,95.9) 35.9,95.1 U13.K2 36.3,91.35 37.3,90.35 37.3,88.1 38.3,87.1 53.2,87.1 v1(54.25,88.15)
  BOTTOM w0.1: 37.15,102.25 36.46,101.56 36.46,101.56 35.28,100.38 35.28,96.57 35.9,95.95
  BOTTOM w0.102: 37.15,102.25 37.15,107 36.3,107.85 U12.K2 v1(35.9,108.9) ; 35.9,95.95 v1(35.9,95.9)
DDR_CS1: length 38.1
  TOP w0.102: U2.P5 v1(55.25,90.15) ; U12.L8 v1(35.1,103.3)
  INNER1 w0.102: v1(35.1,103.3) 35.48,102.92 36.88,102.92 37.15,102.65 37.15,101 37.48,100.67 37.48,97.59 36.85,96.96 36.85,94.75 37.08,94.52 37.08,91.17 37.48,90.77 37.48,88.18 38.38,87.28 51.7,87.28 54,89.59 54.7,89.59 55.25,90.14 v1(55.25,90.15)
DDR_CS2: length 25.2
  TOP w0.102: U13.L8 v1(35.1,89.5) ; U2.N5 v1(55.25,91.15)
  BOTTOM w0.102: v1(55.25,91.15) 54.7,90.6 54.7,90.35 54.05,89.7 52.05,89.7 51.81,89.94 51.81,90.38 51.48,90.71 51.02,90.71 50.5,90.2 50.5,89.45 49.25,88.2 35.8,88.2 35.1,88.9 v1(35.1,89.5)
DDR_DQ0: length 20.1
  TOP w0.102: U12.G8 v1(39.1,103.3) ; U2.F5 v1(55.25,99.15)
  INNER1 w0.102: v1(55.25,99.15) 54.63,98.53 50.42,98.53 49.95,99 49.55,99 49.38,99.16 48.92,99.16 48.75,99 47.05,99 46.88,99.16 46.42,99.16 46.25,99 43.66,99 40.3,102.36 40.3,102.65 40.05,102.9 39.5,102.9 v1(39.1,103.3)
DDR_DQ1: length 19.8
  TOP w0.102: U12.G2 v1(39.1,108.9) ; U2.C2 v1(52.25,102.15)
  INNER1 w0.102: v1(39.1,108.9) 39.1,108.4 39.01,108.31 38.95,108.31 38.86,108.22 38.86,108.1 38.95,108.01 39.01,108.01 39.1,107.92 39.1,107.8 39.01,107.71 38.95,107.71 38.86,107.62 38.86,107.49 38.95,107.41 39.01,107.41 39.1,107.32 39.1,107.19 39.01,107.1 38.95,107.1 38.86,107.02 38.86,106.89 38.95,106.8 39.01,106.8 39.1,106.71 39.1,106.4 40.63,104.86 48.45,104.86 49.91,103.4 49.91,102.84 50.22,102.53 51.87,102.53 v1(52.25,102.15)
DDR_DQ2: length 21.6
  TOP w0.102: U12.H7 v1(38.3,104.1) ; U2.F4 v1(54.25,99.15)
  INNER1 w0.102: v1(54.25,99.15) 53.81,98.71 50.58,98.71 49.31,99.98 48.99,99.98 48.28,99.27 47.52,99.27 46.81,99.98 46.49,99.98 45.71,99.2 43.72,99.2 41.1,101.82 41.1,103 40.38,103.72 38.68,103.72 v1(38.3,104.1)
DDR_DQ3: length 22.3
  TOP w0.102: U2.E4 v1(54.25,100.15) ; U12.H3 v1(38.3,108.1)
  INNER1 w0.102: v1(54.25,100.15) 53.75,100.65 53.15,100.65 52.85,100.95 52.85,101.09 52.41,101.53 50.12,101.53 49.55,102.1 49.55,103.25 48.3,104.5 40.2,104.5 38.3,106.4 v1(38.3,108.1)
DDR_DQ4: length 22.1
  TOP w0.102: U2.D3 v1(53.25,101.15) ; U12.H1 v1(38.3,109.7)
  INNER1 w0.102: v1(38.3,109.7) 38.68,109.32 38.68,106.42 40.42,104.68 48.38,104.68 49.73,103.33 49.73,102.28 50.29,101.71 52.69,101.71 v1(53.25,101.15)
DDR_DQ5: length 20.8
  TOP w0.102: U2.G5 v1(55.25,98.15) ; U12.H9 v1(38.3,102.5)
  INNER1 w0.102: v1(55.25,98.15) 54.63,97.53 50.62,97.53 50.15,98 49.55,98 49.38,98.16 48.92,98.16 48.75,98 47.05,98 46.88,98.16 46.42,98.16 46.25,98 44,98 40.06,101.94 38.86,101.94 v1(38.3,102.5)
DDR_DQ6: length 20.3
  TOP w0.102: U12.F1 v1(39.9,109.7) ; U2.C3 v1(53.25,102.15)
  INNER1 w0.102: v1(39.9,109.7) 39.48,109.28 39.48,106.42 40.85,105.05 48.53,105.05 50.84,102.73 52.67,102.73 v1(53.25,102.15)
DDR_DQ7: length 20.1
  TOP w0.102: U12.F9 v1(39.9,102.5) ; U2.G3 v1(53.25,98.15)
  INNER1 w0.102: v1(39.9,102.5) 39.9,102.4 44.1,98.2 44.34,98.2 44.44,98.3 44.44,98.7 44.54,98.8 44.69,98.8 44.79,98.7 44.79,98.28 44.89,98.18 45.04,98.18 45.14,98.28 45.14,98.73 45.23,98.82 45.37,98.82 45.46,98.73 45.46,98.27 45.55,98.18 45.69,98.18 46.49,98.98 46.81,98.98 47.52,98.27 48.28,98.27 48.99,98.98 49.31,98.98 50.11,98.18 50.23,98.18 50.7,97.71 52.81,97.71 v1(53.25,98.15)
DDR_DQ8: length 19.9
  TOP w0.102: U2.E2 v1(52.25,100.15) ; U12.C8 v1(42.3,103.3)
  INNER1 w0.102: v1(42.3,103.3) 42.7,102.9 42.7,102.13 42.6,102.03 42.33,102.03 42.23,101.93 42.23,101.72 42.33,101.62 42.6,101.62 42.7,101.52 42.7,101.02 43.19,100.53 43.85,100.53 43.96,100.63 43.96,100.73 44.06,100.84 44.67,100.84 44.77,100.94 44.77,101.11 44.87,101.21 45.02,101.21 45.28,100.95 45.58,100.95 45.67,101.04 45.67,101.26 45.76,101.35 45.88,101.35 45.97,101.26 45.97,101.04 46.06,100.95 46.19,100.95 46.27,101.04 46.27,101.26 46.36,101.35 46.49,101.35 46.58,101.26 46.58,101.04 46.66,100.95 46.79,100.95 46.88,101.04 46.88,101.26 46.97,101.35 47.09,101.35 47.18,101.26 47.18,101.04 47.27,100.95 47.53,100.95 47.63,100.85 47.63,100.63 47.73,100.53 47.93,100.53 48.04,100.63 48.04,101.2 48.14,101.3 48.34,101.3 48.44,101.2 48.44,100.63 48.55,100.53 48.75,100.53 48.85,100.63 48.85,101.2 48.95,101.3 49.16,101.3 49.26,101.2 49.26,100.63 49.36,100.53 49.57,100.53 49.67,100.63 49.67,100.73 49.77,100.84 49.97,100.84 50.08,100.73 50.08,100.63 50.18,100.53 51.87,100.53 v1(52.25,100.15)
DDR_DQ9: length 20
  TOP w0.102: U2.B3 v1(53.25,103.15) ; U12.C2 v1(42.3,108.9)
  INNER1 w0.102: v1(42.3,108.9) 42.68,108.52 42.68,107.75 42.78,107.65 43.25,107.65 43.35,107.55 43.35,107.02 43.25,106.92 43.18,106.92 43.08,106.81 43.08,106.62 43.18,106.52 43.32,106.52 44.03,107.23 44.17,107.23 44.32,107.08 44.32,106.94 43.94,106.56 43.94,106.44 44.35,106.03 44.35,105.9 44.26,105.81 44.14,105.81 43.73,106.22 43.6,106.22 43.36,105.98 43.36,105.84 43.61,105.59 48.76,105.59 50.6,103.75 52.65,103.75 v1(53.25,103.15)
DDR_DQ10: length 19.7
  TOP w0.102: U12.D7 v1(41.5,104.1) ; U2.F3 v1(53.25,99.15)
  INNER1 w0.102: v1(53.25,99.15) 52.69,99.71 50.91,99.71 50.81,99.81 50.81,100.22 50.7,100.33 50.5,100.33 50.4,100.22 50.4,99.81 50.3,99.71 50.09,99.71 49.46,100.34 47.44,100.34 47.35,100.43 47.35,100.66 47.27,100.75 47.14,100.75 47.05,100.66 47.05,100.43 46.97,100.34 46.84,100.34 46.75,100.43 46.75,100.66 46.66,100.75 46.54,100.75 46.45,100.66 46.45,100.43 46.36,100.34 46.23,100.34 46.15,100.43 46.15,100.66 46.06,100.75 45.93,100.75 45.84,100.66 45.84,100.43 45.76,100.34 45.63,100.34 45.54,100.43 45.54,100.66 45.45,100.75 45.33,100.75 45.24,100.66 45.24,100.43 45.15,100.34 43.09,100.34 41.88,101.55 41.88,103.46 41.5,103.84 v1(41.5,104.1)
DDR_DQ11: length 19.9
  TOP w0.102: U2.B1 v1(51.25,103.15) ; U12.D3 v1(41.5,108.1)
  INNER1 w0.102: v1(41.5,108.1) 41.5,107.37 41.4,107.27 39.8,107.27 39.7,107.16 39.7,106.96 39.8,106.86 40.1,106.86 40.19,106.77 40.19,106.34 40.28,106.25 40.41,106.25 40.49,106.34 40.49,106.77 40.58,106.86 41.4,106.86 41.5,106.76 41.5,106.09 41.03,105.61 41.03,105.47 41.17,105.33 41.66,105.33 41.94,105.6 42.08,105.6 42.45,105.23 48.6,105.23 50.68,103.15 v1(51.25,103.15)
DDR_DQ12: length 19.8
  TOP w0.102: U2.B2 v1(52.25,103.15) ; U12.D1 v1(41.5,109.7)
  INNER1 w0.102: v1(41.5,109.7) 41.88,109.32 41.88,107.5 41.98,107.4 42.8,107.4 42.9,107.3 42.9,106.97 42.8,106.87 41.98,106.87 41.71,106.59 41.71,106.44 42.09,106.06 42.24,106.06 42.72,106.54 42.86,106.54 43.01,106.39 43.01,106.25 42.6,105.84 42.6,105.7 42.65,105.65 43.2,105.65 43.44,105.41 48.68,105.41 50.54,103.55 51.85,103.55 v1(52.25,103.15)
DDR_DQ13: length 20.4
  TOP w0.102: U12.D9 v1(41.5,102.5) ; U2.F2 v1(52.25,99.15)
  INNER1 w0.102: v1(41.5,102.5) 41.5,101.67 43.17,100 43.66,100 43.76,99.9 43.76,99.5 43.86,99.4 44.06,99.4 44.16,99.5 44.16,100.05 44.27,100.15 44.47,100.15 44.57,100.05 44.57,99.49 44.67,99.39 44.88,99.39 44.98,99.49 44.98,100.05 45.08,100.15 45.29,100.15 45.39,100.05 45.39,99.55 45.49,99.45 45.7,99.45 45.8,99.55 45.8,99.9 45.9,100 46.25,100 46.42,100.16 46.88,100.16 47.05,100 47.67,100 47.77,99.9 47.77,99.6 47.87,99.49 48.08,99.49 48.18,99.6 48.18,99.9 48.28,100 48.75,100 48.92,100.16 49.38,100.16 50.02,99.53 50.5,99.53 50.6,99.43 50.6,99 50.7,98.9 50.87,98.9 50.97,99 50.97,99.43 51.07,99.53 51.23,99.53 51.31,99.44 51.31,98.98 51.4,98.9 51.55,98.9 51.64,98.98 51.64,99.44 51.72,99.53 51.87,99.53 v1(52.25,99.15)
DDR_DQ14: length 19.8
  TOP w0.102: U2.A2 v1(52.25,104.15) ; U12.B1 v1(43.1,109.7)
  INNER1 w0.102: v1(43.1,109.7) 43.52,109.28 43.52,109.06 43.62,108.96 43.72,108.96 43.83,108.86 43.83,108.66 43.72,108.56 43.62,108.56 43.52,108.45 43.52,107.68 43.64,107.56 44.4,107.56 44.5,107.46 44.5,106.78 44.72,106.56 44.84,106.56 45.08,106.8 45.2,106.8 45.29,106.71 45.29,106.59 44.72,106.01 44.72,105.89 44.8,105.8 44.93,105.8 45.5,106.37 45.63,106.37 45.72,106.28 45.72,106.16 45.6,106.04 45.6,105.88 45.7,105.77 46.37,105.77 46.47,105.88 46.47,105.98 46.57,106.08 46.78,106.08 46.88,105.98 46.88,105.88 46.98,105.77 47.19,105.77 47.29,105.88 47.29,105.98 47.39,106.08 47.59,106.08 47.7,105.98 47.7,105.88 47.8,105.77 48,105.77 48.1,105.88 48.1,105.98 48.21,106.08 48.41,106.08 48.51,105.98 48.51,105.88 48.61,105.77 48.88,105.77 49.27,105.38 49.41,105.38 49.87,105.84 50.01,105.84 50.16,105.69 50.16,105.55 49.7,105.09 49.7,104.95 50.1,104.55 50.67,104.55 50.77,104.65 50.77,104.75 50.87,104.86 51.08,104.86 51.18,104.75 51.18,104.65 51.28,104.55 51.85,104.55 v1(52.25,104.15)
DDR_DQ15: length 19.8
  TOP w0.102: v1(53.25,100.15) U2.E3 ; U12.B9 v1(43.1,102.5)
  INNER1 w0.102: v1(53.25,100.15) 52.69,100.71 50.59,100.71 50.29,101.02 49.9,101.02 49.8,101.12 49.8,101.43 49.7,101.53 48.19,101.53 48.08,101.63 48.08,102.6 47.98,102.7 47.78,102.7 47.68,102.6 47.68,101.63 47.57,101.53 45.74,101.53 45.64,101.63 45.64,102.5 45.53,102.6 45.33,102.6 45.23,102.5 45.23,101.6 45.13,101.5 44.92,101.5 44.82,101.6 44.82,102.5 44.72,102.6 44.51,102.6 44.41,102.5 44.41,101.12 44.31,101.02 43.61,101.02 43.1,101.53 v1(43.1,102.5)
DDR_DQ16: length 19.8
  TOP w0.102: U2.L3 v1(53.25,93.15) ; U13.G8 v1(39.1,89.5)
  INNER1 w0.102: v1(39.1,89.5) 39.48,89.88 40.83,89.88 41.12,90.17 41.12,90.46 41.71,91.05 42.53,91.05 43.28,91.8 43.51,91.8 43.82,92.1 46.1,92.1 46.42,92.41 47.08,92.41 47.16,92.5 47.16,92.96 47.25,93.05 47.38,93.05 47.47,92.96 47.47,92.5 47.55,92.41 48.16,92.41 48.38,92.62 48.3,92.7 47.8,92.7 47.75,92.75 47.75,92.9 47.83,92.97 48.72,92.97 49,93.25 50.81,93.25 51.09,93.53 52.87,93.53 v1(53.25,93.15)
DDR_DQ17: length 19.9
  TOP w0.102: U2.H5 v1(55.25,97.15) ; U13.G2 v1(39.1,95.1)
  INNER1 w0.102: v1(55.25,97.15) 54.61,96.51 53.01,96.51 52.7,96.2 50.74,96.2 50.67,96.27 49.96,96.27 49.77,96.08 48.81,96.08 48.31,96.58 47.54,96.58 47.04,96.08 46.08,96.08 45.49,96.68 44.68,96.68 44.55,96.55 44.38,96.55 44.25,96.68 44.08,96.68 43.95,96.55 43.77,96.55 43.65,96.68 43.34,96.68 42.72,96.06 42.72,95.77 42.43,95.48 41.34,95.48 40.96,95.1 40.44,95.1 40.06,94.72 39.74,94.72 39.36,95.1 v1(39.1,95.1)
DDR_DQ18: length 19.8
  TOP w0.102: U13.H7 v1(38.3,90.3) ; U2.K5 v1(55.25,94.15)
  INNER1 w0.102: v1(55.25,94.15) 54.87,93.77 50.97,93.77 50.67,93.47 48.92,93.47 48.68,93.23 46.49,93.23 45.55,92.28 43.74,92.28 43.44,91.98 43.21,91.98 42.46,91.23 41.63,91.23 41.08,90.68 38.68,90.68 v1(38.3,90.3)
DDR_DQ19: length 19.7
  TOP w0.102: U2.K2 v1(52.25,94.15) ; U13.H3 v1(38.3,94.3)
  INNER1 w0.102: v1(52.25,94.15) 51.87,94.53 51.09,94.53 50.88,94.32 50.51,94.32 50.41,94.22 50.41,94.11 50.31,94.01 50.1,94.01 50,94.11 50,94.22 49.9,94.32 48.85,94.32 48.75,94.22 48.75,93.6 48.65,93.5 47.15,93.5 47.05,93.6 47.05,94.22 46.95,94.32 46.2,94.32 46.1,94.22 46.1,93.55 46,93.45 43.03,93.45 42.95,93.36 42.95,93.09 42.86,93 42.73,93 42.64,93.09 42.64,93.36 42.56,93.45 42.43,93.45 42.34,93.36 42.34,93.09 42.25,93 42.13,93 42.04,93.09 42.04,93.36 41.95,93.45 41.65,93.45 41.18,93.92 38.68,93.92 v1(38.3,94.3)
DDR_DQ20: length 20.4
  TOP w0.102: U13.H1 v1(38.3,95.9) ; U2.H3 v1(53.25,97.15)
  INNER1 w0.1: v1(38.3,95.9) 38.3,96.9 38.5,97.1 39.35,97.1 39.5,96.95 39.5,95.67 39.65,95.52
  INNER1 w0.102: v1(53.25,97.15) 52.97,96.87 52.77,96.87 52.47,96.56 50.96,96.56 50.89,96.63 50.52,96.63 50.13,97.02 49.53,97.02 49.38,97.16 48.71,97.16 48.63,97.25 47.51,97.25 47.43,97.16 46.35,97.16 46.04,97.47 42.81,97.47 42.58,97.24 41.5,97.24 40.32,96.06 40.32,95.77 40.07,95.52 39.65,95.52
DDR_DQ21: length 20.2
  TOP w0.102: U2.L5 v1(55.25,93.15) ; U13.H9 v1(38.3,88.7)
  INNER1 w0.102: v1(38.3,88.7) 38.68,89.08 40.28,89.08 41.08,89.88 41.63,89.88 41.92,90.17 41.92,90.46 42.14,90.68 42.68,90.68 43.44,91.43 47.82,91.43 48.64,92.25 50.8,92.25 51.1,92.55 54.65,92.55 v1(55.25,93.15)
DDR_DQ22: length 19.8
  TOP w0.102: v1(52.35,97.1) 52.35,97.05 U2.H2 ; U13.F1 v1(39.9,95.9)
  INNER1 w0.102: v1(52.35,97.1) 52,96.75 51.03,96.75 50.97,96.82 50.59,96.82 50.21,97.2 50.09,97.2 49.31,97.98 48.99,97.98 48.44,97.43 48.2,97.43 48.1,97.53 48.1,97.63 48,97.73 47.8,97.73 47.7,97.63 47.7,97.53 47.59,97.43 47.36,97.43 46.81,97.98 46.49,97.98 46.16,97.65 43.54,97.65 43.44,97.75 43.44,98.25 43.34,98.35 43.14,98.35 43.03,98.25 43.03,97.75 42.93,97.65 42.73,97.65 42.5,97.42 42.3,97.42 42.19,97.52 42.19,98.1 42.09,98.2 41.89,98.2 41.79,98.1 41.79,97.52 41.68,97.42 41.42,97.42 40.92,96.92 40.78,96.92 40.37,97.33 40.23,97.33 40.08,97.18 40.08,97.04 40.49,96.63 40.49,96.49 v1(39.9,95.9)
DDR_DQ23: length 19.9
  TOP w0.102: U13.F9 v1(39.9,88.7) ; U2.M4 v1(54.25,92.15)
  INNER1 w0.102: v1(54.25,92.15) 53.81,91.71 53.11,91.71 53.03,91.8 53.03,92.26 52.94,92.35 52.81,92.35 52.72,92.26 52.72,91.8 52.64,91.71 51.02,91.71 50.77,91.47 50.17,91.47 50.08,91.56 50.08,91.96 49.99,92.05 49.87,92.05 49.78,91.96 49.78,91.56 49.69,91.47 48.12,91.47 47.9,91.25 44.29,91.25 44.2,91.16 44.2,90.99 44.11,90.9 43.99,90.9 43.9,90.99 43.9,91.16 43.81,91.25 43.51,91.25 42.72,90.46 42.72,90.18 42.46,89.92 42.18,89.92 41.92,89.66 41.92,89.38 41.66,89.12 40.58,89.12 40.16,88.7 v1(39.9,88.7)
DDR_DQ24: length 19.8
  TOP w0.102: U13.C8 v1(42.3,89.5) ; U2.M5 v1(55.25,92.15)
  INNER1 w0.102: v1(42.3,89.5) 42.68,89.88 43.23,89.88 43.52,90.17 43.52,90.46 43.74,90.68 44.06,90.68 44.34,90.4 44.59,90.4 44.69,90.5 44.69,90.85 44.79,90.95 44.99,90.95 45.1,90.85 45.1,90.5 45.2,90.4 45.4,90.4 45.5,90.5 45.5,90.85 45.61,90.95 45.81,90.95 45.91,90.85 45.91,90.5 46.02,90.4 47.11,90.4 47.2,90.49 47.2,90.91 47.29,91 47.42,91 47.5,90.91 47.5,90.49 47.59,90.4 47.9,90.4 48.73,91.23 49.78,91.23 49.88,91.13 49.88,90.75 49.98,90.65 50.19,90.65 50.29,90.75 50.29,91.13 50.39,91.23 50.79,91.23 51.09,91.53 51.31,91.53 51.4,91.44 51.4,91.29 51.49,91.2 51.7,91.2 51.78,91.29 51.78,91.44 51.87,91.53 54.63,91.53 v1(55.25,92.15)
