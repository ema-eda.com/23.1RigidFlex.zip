# Allegro board RigidFlex.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_DQ25: length 19.9
  TOP w0.102: U2.J3 v1(53.25,95.15) ; U13.C2 v1(42.3,95.1)
  INNER1 w0.102: v1(42.3,95.1) 42.56,95.1 42.94,95.48 43.26,95.48 43.65,95.09 43.95,95.09 44.04,95 44.04,94.79 44.13,94.7 44.25,94.7 44.34,94.79 44.34,95 44.43,95.09 44.55,95.09 44.64,95 44.64,94.34 44.73,94.25 44.86,94.25 44.95,94.34 44.95,95 45.03,95.09 45.16,95.09 45.25,95 45.25,94.79 45.33,94.7 45.46,94.7 45.55,94.79 45.55,95 45.64,95.09 45.76,95.09 45.85,95 45.85,94.79 45.94,94.7 46.06,94.7 46.15,94.79 46.15,95 46.24,95.09 47.21,95.09 47.31,95.19 47.31,95.5 47.41,95.6 47.62,95.6 47.72,95.5 47.72,94.95 47.82,94.85 48.08,94.85 48.19,94.95 48.19,95.5 48.29,95.6 48.43,95.6 48.53,95.5 48.53,95.19 48.64,95.09 49.81,95.09 49.91,95.19 49.91,95.5 50.01,95.6 50.16,95.6 50.26,95.5 50.26,95.19 50.42,95.03 50.42,94.88 50.55,94.75 50.7,94.75 50.85,94.9 51.15,94.9 51.25,95 51.25,95.4 51.35,95.5 51.64,95.5 51.77,95.63 51.77,95.73 51.88,95.84 52.08,95.84 52.18,95.73 52.18,95.63 52.28,95.53 52.87,95.53 v1(53.25,95.15)
DDR_DQ26: length 19.8
  TOP w0.102: U2.L4 v1(54.25,93.15) ; U13.D7 v1(41.5,90.3)
  INNER1 w0.102: v1(54.25,93.15) 53.83,92.73 51.65,92.73 51.56,92.82 51.56,93.26 51.48,93.35 51.35,93.35 51.26,93.26 51.26,92.82 51.17,92.73 51.02,92.73 50.84,92.55 50.7,92.55 50.55,92.7 50.55,92.97 50.45,93.07 50.31,93.07 50.21,92.97 50.21,92.55 50.1,92.45 49.96,92.45 49.87,92.54 49.87,92.96 49.78,93.05 49.64,93.05 49.55,92.96 49.55,92.54 49.46,92.45 48.5,92.45 48.28,92.23 47.67,92.23 47.56,92.13 47.56,91.72 47.46,91.61 47.26,91.61 47.16,91.72 47.16,92.13 47.05,92.23 46.49,92.23 45.88,91.61 45.33,91.61 45.23,91.72 45.23,91.82 45.12,91.92 44.92,91.92 44.82,91.82 44.82,91.72 44.72,91.61 44.51,91.61 44.41,91.72 44.41,91.82 44.31,91.92 44.1,91.92 44,91.82 44,91.72 43.9,91.61 43.36,91.61 42.61,90.86 42.06,90.86 v1(41.5,90.3)
DDR_DQ27: length 19.9
  TOP w0.102: U13.D3 v1(41.5,94.3) ; U2.K3 v1(53.25,94.15)
  INNER1 w0.1: 46.18,94.5 45.95,94.5 45.1,93.65 44.22,93.65 44.14,93.74 44.14,93.81 44.05,93.9 43.92,93.9 43.84,93.81 43.84,93.74 43.75,93.65 43.62,93.65 43.54,93.74 43.54,93.81 43.45,93.9 43.33,93.9 43.24,93.81 43.24,93.74 43.15,93.65 43.02,93.65 42.94,93.74 42.94,93.81 42.85,93.9 42.72,93.9 42.64,93.81 42.64,93.74 42.55,93.65 42.15,93.65 v1(41.5,94.3)
  INNER1 w0.102: 46.18,94.5 46.39,94.5 46.49,94.6 46.49,94.81 46.59,94.91 46.79,94.91 46.9,94.81 46.9,94.6 47,94.5 47.14,94.5 47.24,94.6 47.24,94.81 47.35,94.91 47.49,94.91 47.59,94.81 47.59,93.8 47.7,93.7 48.14,93.7 48.24,93.8 48.24,94.6 48.34,94.7 48.49,94.7 48.69,94.5 48.83,94.5 48.94,94.6 48.94,94.81 49.04,94.91 49.24,94.91 49.34,94.81 49.34,94.6 49.45,94.5 49.65,94.5 49.75,94.6 49.75,94.81 49.85,94.91 50.06,94.91 50.16,94.81 50.16,94.6 50.26,94.5 50.8,94.5 51.02,94.71 51.36,94.71 51.45,94.8 51.45,95.21 51.54,95.3 51.66,95.3 51.75,95.21 51.75,94.8 51.84,94.71 52.29,94.71 52.85,94.15 v1(53.25,94.15)
DDR_DQ28: length 20.3
  TOP w0.102: U13.D1 v1(41.5,95.9) ; U2.H4 v1(54.25,97.15)
  INNER1 w0.102: v1(54.25,97.15) 53.79,96.69 52.89,96.69 52.58,96.38 50.88,96.38 50.81,96.45 49.84,96.45 49.31,96.98 48.99,96.98 48.77,96.76 48.2,96.76 48.1,96.86 48.1,96.96 48,97.06 47.8,97.06 47.7,96.96 47.7,96.86 47.59,96.76 47.03,96.76 46.81,96.98 45.95,96.98 45.85,97.08 45.85,97.19 45.74,97.29 45.54,97.29 45.44,97.19 45.44,97 45.34,96.9 45.13,96.9 45.03,97 45.03,97.19 44.93,97.29 44.72,97.29 44.62,97.19 44.62,97 44.52,96.9 44.32,96.9 44.21,97 44.21,97.19 44.11,97.29 43.91,97.29 43.81,97.19 43.81,97 43.7,96.9 43.5,96.9 43.4,97 43.4,97.15 43.3,97.25 43.02,97.25 42.78,97.01 42.05,97.01 41.98,96.93 41.98,96.83 42.05,96.76 42.65,96.76 42.75,96.65 42.75,96.45 42.65,96.35 42.41,96.35 42.3,96.46 41.94,96.46 41.61,96.79 41.49,96.79 41.39,96.69 41.39,96.56 41.71,96.24 41.71,96.11 v1(41.5,95.9)
DDR_DQ29: length 20.3
  TOP w0.102: U2.N3 v1(53.25,91.15) ; U13.D9 v1(41.5,88.7)
  INNER1 w0.102: v1(53.25,91.15) 52.81,90.71 51.02,90.71 50.77,90.47 49.09,90.47 49,90.38 49,90.29 48.91,90.2 48.56,90.2 48.47,90.11 48.47,89.44 48.39,89.35 48.26,89.35 48.17,89.44 48.17,90.11 48.08,90.2 47.77,90.2 47.67,90.1 47.67,89.45 47.57,89.35 47.42,89.35 47.32,89.45 47.32,90.1 47.22,90.2 46.02,90.2 45.91,90.1 45.91,89.4 45.81,89.3 45.61,89.3 45.5,89.4 45.5,90.1 45.4,90.2 45.2,90.2 45.1,90.1 45.1,89.4 44.99,89.3 44.79,89.3 44.69,89.4 44.69,90.1 44.59,90.2 44.34,90.2 44.06,89.92 43.78,89.92 43.52,89.66 43.52,89.37 43.23,89.08 41.88,89.08 v1(41.5,88.7)
DDR_DQ30: length 19.8
  TOP w0.102: U2.J4 v1(54.25,95.15) ; U13.B1 v1(43.1,95.9)
  INNER1 w0.1: v1(43.1,95.9) 43.55,96.35 44.37,96.35 44.46,96.26 44.46,95.44 44.55,95.35 44.67,95.35 44.76,95.44 44.76,96.26 44.85,96.35 45.46,96.35 45.6,96.21
  INNER1 w0.102: v1(54.25,95.15) 53.69,95.71 53.48,95.71 53.38,95.81 53.38,96.22 53.28,96.33 53.08,96.33 52.97,96.22 52.97,95.81 52.87,95.71 52.67,95.71 52.37,96.02 51.59,96.02 51.36,95.78 50.66,95.78 50.55,95.88 50.55,95.99 50.45,96.09 50.25,96.09 50.14,95.99 50.14,95.88 50.04,95.78 49.83,95.78 49.36,95.31 49.05,95.31 48.58,95.78 48.23,95.78 48.13,95.88 48.13,96.29 48.03,96.39 47.82,96.39 47.72,96.29 47.72,95.88 47.62,95.78 47.27,95.78 46.8,95.31 46.5,95.31 46.05,95.76 45.92,95.76 45.4,95.24 45.27,95.24 45.18,95.33 45.18,95.45 45.71,95.98 45.71,96.1 45.6,96.21
DDR_DQ31: length 20.8
  TOP w0.102: U13.B9 v1(43.1,88.7) ; U2.N4 v1(54.25,91.15)
  INNER1 w0.102: v1(43.1,88.7) 43.25,88.7 43.63,89.08 44.57,89.08 44.66,88.99 44.66,88.44 44.75,88.35 44.87,88.35 44.96,88.44 44.96,88.99 45.05,89.08 45.18,89.08 45.26,88.99 45.26,88.44 45.35,88.35 45.48,88.35 45.57,88.44 45.57,88.99 45.65,89.08 47.46,89.08 47.55,88.99 47.55,88.54 47.64,88.45 47.76,88.45 47.85,88.54 47.85,88.99 47.94,89.08 48.06,89.08 48.15,88.99 48.15,88.54 48.24,88.45 48.37,88.45 48.45,88.54 48.45,88.99 48.54,89.08 48.68,89.08 48.85,89.25 49.77,89.25 49.97,89.05 49.97,88.15 50.07,88.05 50.27,88.05 50.37,88.15 50.37,90.15 50.48,90.25 50.81,90.25 51.09,90.53 53.63,90.53 v1(54.25,91.15)
DDR_LDM1: length 48.7
  TOP w0.102: U2.P6 v1(56.25,90.15) ; U12.F3 v1(39.9,108.1)
  INNER1 w0.102: v1(39.9,108.1) 40.32,108.52 40.32,109.88 40.1,110.1 38.05,110.1 37.8,109.85 37.8,104.8 37.33,104.33 37.33,101.08 37.66,100.75 37.66,97.52 37.07,96.92 37.07,94.84 37.26,94.65 37.26,91.25 37.66,90.84 37.66,88.29 38.45,87.5 51.66,87.5 54.71,90.55 55.85,90.55 v1(56.25,90.15)
DDR_LDM2: length 19.5
  TOP w0.102: U13.F3 v1(39.9,94.3) ; U2.N6 v1(56.25,91.15)
  INNER2 w0.102: v1(56.25,91.15) 55.87,91.53 53.42,91.53 52.4,92.55 51.65,92.55 51.45,92.75 51,92.75 49.4,94.35 45.45,94.35 44.75,93.65 40.55,93.65 v1(39.9,94.3)
DDR_LDQS1: length 41.9
  TOP w0.102: U12.F7 v1(39.9,104.1) ; U2.M6 v1(56.25,92.15)
  INNER1 w0.102: v1(56.25,92.15) 55.8,91.7 55.8,90.95 55.6,90.75 54.65,90.75 51.6,87.7 38.55,87.7 37.85,88.4 37.85,90.92 37.45,91.32 37.45,93.34 37.9,93.8 37.9,96.85 38.5,97.45 38.5,100.39 38.26,100.63 38.08,100.63 37.51,101.2 37.51,104.21 37.85,104.55 39.45,104.55 v1(39.9,104.1)
DDR_LDQS2: length 20.3
  TOP w0.102: U2.T6 v1(56.25,88.15) ; U13.F7 v1(39.9,90.3)
  INNER2 w0.102: v1(39.9,90.3) 40.28,89.92 40.28,88.32 41.1,87.5 52.06,87.5 53.09,88.53 55.41,88.53 55.79,88.15 v1(56.25,88.15)
DDR_ODT1: length 42.1
  TOP w0.102: U2.T7 v1(57.25,88.15) ; U12.K9 v1(35.9,102.5)
  INNER1 w0.102: v1(57.25,88.15) 57.25,86.9 56.55,86.2 56.55,85.85 56.3,85.6 53.55,85.6 52.85,86.3 35.6,86.3 34.9,87 34.9,88.4 35.52,89.02 35.52,100.67 35.9,101.05 v1(35.9,102.5)
DDR_ODT2: length 26.4
  TOP w0.102: U2.R7 v1(57.25,89.15) ; U13.K9 v1(35.9,88.7)
  INNER1 w0.102: v1(35.9,88.7) 35.85,88.65 35.85,87.3 36.02,87.13 36.02,87.05 36.57,86.5 55.97,86.5 56.7,87.23 56.7,88.55 57.25,89.1 v1(57.25,89.15)
DDR_RAS: length 45.7
  TOP w0.1: U2.P7 57.75,90.15 58.1,89.8 58.1,88.22 57.45,87.57 46.99,87.57 46.09,88.47 46.09,89.21 44.05,91.25 36.9,91.25 36.35,90.7 U13.K7
  TOP w0.102: v1(35.9,90.3) U13.K7 ; U12.K7 v1(35.9,104.1)
  INNER2 w0.102: v1(35.9,90.3) 35.9,90.55 36.3,90.95 36.3,93.2 37.1,94 37.1,94.5 36.46,95.14 36.46,96.39 36.15,96.7 34.55,96.7 34.1,97.15 34.1,101.15 35.45,102.5 35.45,102.65 35.7,102.9 36.08,102.9 36.28,103.1 36.28,103.72 v1(35.9,104.1)
DDR_UDM1: length 29.6
  TOP w0.102: U2.M7 v1(57.25,92.15) ; U12.B3 v1(43.1,108.1)
  INNER2 w0.102: v1(43.1,108.1) 44.05,107.15 44.05,106.5 44.65,105.9 44.65,101.8 44.83,101.62 50.87,101.62 51,101.75 51.55,101.75 51.81,101.49 51.81,96.8 52.01,96.6 52.01,96.59 52.55,96.05 53.16,96.05 53.83,95.38 53.83,95.03 54.13,94.73 55.52,94.73 55.88,94.37 55.88,94.05 56.2,93.73 57.47,93.73 57.85,93.35 57.85,92.75 v1(57.25,92.15)
DDR_UDM2: length 16.7
  TOP w0.102: U13.B3 v1(43.1,94.3) ; U2.L7 v1(57.25,93.15)
  INNER2 w0.102: v1(43.1,94.3) 43.5,93.9 44.4,93.9 45.03,94.53 49.51,94.53 50.22,93.82 50.23,93.82 51.1,92.95 51.55,92.95 51.73,92.77 56.41,92.77 56.79,93.15 v1(57.25,93.15)
DDR_UDQS1_N: length 29.6
  TOP w0.102: U2.T9 59.25,89.15 v1(59.25,89.95) ; U12.A8 v1(43.9,103.3)
  INNER2 w0.102: v1(43.9,103.3) 44.45,102.75 44.45,101.7 44.75,101.4 50.95,101.4 51.1,101.55 51.45,101.55 51.63,101.37 51.63,96.67 52.45,95.85 53.1,95.85 53.65,95.3 53.65,94.95 54.05,94.55 55.4,94.55 55.7,94.25 55.7,93.95 56.1,93.55 57.39,93.55 57.63,93.31 57.63,92.93 57.4,92.7 57,92.7 56.75,92.45 56.75,91.9 57,91.65 58.35,91.65 58.95,91.05 58.95,90.25 v1(59.25,89.95)
DDR_UDQS1_P: length 32.3
  TOP w0.1: U12.B7 43.45,105.25 50.83,105.25 ; 59.23,104.67 59.3,104.6 59.3,90.55 59.75,90.1 U2.R9
  TOP w0.2: 59.23,104.67 58.65,105.25 50.83,105.25
DDR_UDQS2_N: length 19.3
  TOP w0.102: U13.B7 v1(43.1,90.3) ; U2.P9 v1(60.25,90.15)
  INNER2 w0.1: 49.5,90.2 50.15,89.55 59.65,89.55 v1(60.25,90.15)
  INNER2 w0.102: v1(43.1,90.3) 43.48,90.68 44.06,90.68 44.54,90.2 49.5,90.2
DDR_UDQS2_P: length 21.8
  TOP w0.102: U13.A8 v1(43.9,89.5) ; U2.N9 v1(60.25,91.15)
  INNER2 w0.102: v1(60.25,91.15) 60.25,91.1 60.65,90.7 60.65,89.95 60.05,89.35 59.1,89.35 58.5,88.75 53,88.75 51.93,87.68 44.42,87.68 44.28,87.82 44.28,89.12 v1(43.9,89.5)
DDR_WE: length 45.6
  TOP w0.102: U2.P8 v1(58.25,91.15) ; U13.K3 v1(35.9,94.3) ; U12.K3 v1(35.9,108.1)
  INNER2 w0.102: v1(35.9,108.1) 35.5,108.5 34.15,108.5 33.9,108.25 33.9,105.4 34.72,104.58 34.72,103.14 34.88,102.98 34.88,102.5 33.68,101.3 33.68,96.93 34.33,96.28 35.4,96.28 35.5,96.18 35.5,95.6 35.9,95.2 v1(35.9,94.3)
  BOTTOM w0.102: v1(58.25,91.15) 57.85,91.55 51.87,91.55 51.65,91.77 50.07,91.77 49.6,91.3 48.76,91.3 48.75,91.31 47.05,91.31 47.04,91.3 37.15,91.3 35.9,92.55 v1(35.9,94.3)
DDS.DATA0: length 21.4
  TOP w0.102: U2.B10 v1(61.25,103.15)
  TOP w0.2: v2(71.8,113.85) 72.5,113.16 U4.4
  INNER1 w0.102: 61.49,104.67 61.25,104.43 v1(61.25,103.15)
  INNER1 w0.2: 61.49,104.67 62.22,105.4 63.28,105.4 64.75,106.87 64.75,111.55 66.75,113.55 71.5,113.55 v2(71.8,113.85)
DDS.DATA1: length 24
  TOP w0.102: U2.C10 v1(61.25,102.15)
  TOP w0.2: U4.3 v2(75.1,113.81)
  INNER1 w0.102: v1(61.25,102.15) 61.8,102.7 61.8,103.55 61.95,103.7 62.75,103.7 63.72,104.67
  INNER1 w0.2: 63.72,104.67 63.72,104.7 65.55,106.53 65.55,111.18 67.12,112.75 73.36,112.75 74.41,113.81 v2(75.1,113.81)
DDS.DATA2: length 25
  TOP w0.102: U2.E10 v1(61.25,100.15)
  TOP w0.2: v2(72.32,114.47) 72.34,114.46 U4.2
  INNER1 w0.102: 60.92,104.67 60.87,104.62 60.87,100.53 v1(61.25,100.15)
  INNER1 w0.2: v2(72.32,114.47) 72.32,114.47 72.3,114.46 71.55,114.46 71.54,114.45 71.35,114.45 70.85,113.95 66.58,113.95 64.35,111.72 64.35,107.03 63.12,105.8 62.05,105.8 60.92,104.67
DDS.DATA3: length 29.7
  TOP w0.102: U2.F10 v1(61.25,99.15)
  TOP w0.2: U4.1 v2(75.1,115.11)
  INNER1 w0.102: v1(61.25,99.15) 61.25,99.6 60.69,100.16 60.69,103.71 60.5,103.9 60.5,104.67
  INNER1 w0.2: 60.5,104.67 60.5,104.9 61.4,105.8 61.48,105.8 61.88,106.2 62.95,106.2 63.95,107.2 63.95,111.88 66.42,114.35 70.65,114.35 71.41,115.11 v2(75.1,115.11)
DDS.DATA4: length 34.5
  TOP w0.102: U2.E11 v1(62.25,100.15)
  TOP w0.2: U4.28 v2(82.3,115.11)
  INNER2 w0.1: 67.63,104.67 67.63,103.99 66.98,103.34
  INNER2 w0.102: v1(62.25,100.15) 62.6,100.5 64.6,100.5 65.93,101.83 65.93,103.11 66.16,103.34 66.98,103.34
  INNER2 w0.2: v2(82.3,115.11) 81.05,113.85 78.05,113.85 76.8,112.6 76.8,111.73 76.8,111.4 76.8,111.4 76.8,111.39 75.62,110.2 74.69,110.2 72.94,111.95 70.05,111.95 69,110.9 69,106.47 67.63,105.1 67.63,104.67
DDS.DATA5: length 31.5
  TOP w0.102: U2.D11 v1(62.25,101.15)
  TOP w0.2: U4.27 v2(79.54,114.46)
  INNER2 w0.1: 65.75,101.9 65.75,103.18 66.08,103.52 66.58,103.52 66.83,103.77 66.83,104.27 67.05,104.49 67.05,104.67
  INNER2 w0.102: v1(62.25,101.15) 62.7,100.7 64.54,100.7 65.75,101.9
  INNER2 w0.2: v2(79.54,114.46) 79.5,114.5 78.15,114.5 77.9,114.25 77.88,114.25 76.4,112.77 76.4,111.55 75.45,110.6 74.85,110.6 73.1,112.35 69.84,112.35 68.6,111.11 68.6,106.63 67.05,105.08 67.05,104.67
DDS.DATA6: length 30.5
  TOP w0.102: U2.C11 v1(62.25,102.15)
  TOP w0.2: U4.26 v2(82.3,113.81)
  INNER1 w0.102: 64.25,104.67 64.17,104.67 62.7,103.2 62.7,102.55 62.3,102.15 v1(62.25,102.15)
  INNER1 w0.2: v2(82.3,113.81) 82.3,113.8 81.05,113.8 79.8,112.55 78.1,112.55 77.45,113.2 74.38,113.2 73.53,112.35 67.4,112.35 65.95,110.9 65.95,106.37 64.25,104.67
DDS.DATA7: length 27.3
  TOP w0.102: U2.A11 v1(62.25,104.15)
  TOP w0.2: U4.25 v2(79.54,113.16)
  INNER1 w0.102: 62.25,104.67 v1(62.25,104.15)
  INNER1 w0.2: v2(79.54,113.16) 78.14,113.16 76.89,114.41 74.45,114.41 73.19,113.15 66.95,113.15 65.15,111.35 65.15,106.7 63.45,105 62.45,105 62.25,104.8 62.25,104.67
DDS.FQUD: length 18
  TOP w0.102: U2.B12 v1(63.25,103.15)
  TOP w0.2: U4.8 v2(72.34,110.56)
  INNER1 w0.102: v1(63.25,103.15) 63.7,103.6 65.45,103.6 65.75,103.9 65.75,104.67
  INNER1 w0.2: v2(72.34,110.56) 72.34,110.55 71.3,110.55 70.66,111.19 67.46,111.19 66.75,110.48 66.75,106.04 65.75,105.04 65.75,104.67
DDS.RESET: length 26.4
  TOP w0.102: U2.A13 v1(64.25,104.15)
  TOP w0.2: U4.22 v2(82.3,111.21)
  INNER1 w0.102: 64.82,104.67 64.77,104.67 v1(64.25,104.15)
  INNER1 w0.2: v2(82.3,111.21) 81.41,112.1 78.75,112.1 78.55,111.9 72.26,111.9 72.25,111.91 71.75,111.91 71.74,111.9 67.6,111.9 66.35,110.65 66.35,106.2 64.82,104.67
DDS.WCLK: length 20
  TOP w0.102: U2.A14 v1(65.25,104.15)
  TOP w0.2: U4.7 v2(75.1,111.21)
  INNER2 w0.1: 66.5,103.7 66.65,103.85 66.65,104.47
  INNER2 w0.102: 66.5,103.7 65.65,103.7 65.25,104.1 v1(65.25,104.15)
  INNER2 w0.2: 66.65,104.47 66.65,105.25 68.2,106.8 68.2,111.3 69.65,112.75 73.56,112.75 v2(75.1,111.21)
DDS_CLK: length 64.2
  TOP w0.2: U4.9 73.72,109.9 v2(71.7,109.9)
  INNER1 w0.2: L4.2 49.79,73.55 62.05,73.55 64.6,76.1 64.6,79.2 65.3,79.9 71.05,79.9 73.1,81.95 73.1,84.1 74.63,85.64 74.63,108.17 72.9,109.9 v2(71.7,109.9)
DDS_OUT: length 41.7
  TOP w0.2: U4.20 v2(82.3,109.91)
  TOP w0.5: v2(103.6,123) 103.6,124.18 L5.1 106.33,124.22 C34.2 108.2,124.57 C36.2
  BOTTOM w0.5: v2(103.6,123) 103.6,111.5 102,109.91 v2(82.3,109.91)
DEN/: length 66.5
  TOP w0.2: U7.17 27.37,84.07 28.68,85.38 28.68,105.59 28.22,106.05 26.79,106.05 ; U6.48 25.65,139.85 v2(26.85,139.85) ; U9.48 25.54,106.05 26.79,106.05 ; 26.79,106.05 v2(26.75,106.09)
  BOTTOM w0.2: v2(26.85,139.85) 22.32,135.32 22.32,120.35 22.67,120 24.41,120 25.1,119.3 25.1,112.66 26.75,111.02 v2(26.75,106.09)
DHEN/: length 33.1
  TOP w0.2: 26.04,85.34 27.21,85.34 v2(27.45,85.1) ; v2(27.15,112.65) 27.15,112.65 27.15,112.3 26.67,111.82 26.67,111.82 26.49,111.64 26.49,111.64 26.45,111.6 25.65,111.6 U8.25
  INNER2 w0.2: v2(27.45,85.1) 29.6,87.25 29.6,110.2 v2(27.15,112.65)
DI: length 63.2
  TOP w0.102: U1.C12 v1(42.9,121.2)
  INNER1 w0.102: v1(42.9,121.2) 42.95,121.15 42.95,118.74
  INNER1 w0.2: P1.7 42.68,82.82 41.65,83.85 29.95,83.85 29.5,84.3 29.5,108.18 34.32,113 42,113 42.95,113.95 42.95,118.74
DIFF1+: length 47.1
  TOP w0.102: U1.D16 v1(38.9,122.2)
  TOP w0.127: U8.20 19,113.59 19.12,113.72 19.71,113.72 23.65,117.66 23.65,120.79 v2(23.83,120.97) 23.55,121.25 23.55,121.37 23.55,121.38 23.55,122.21 22.6,123.16 22.6,132.45 21.1,133.96 21.1,136.2 19.57,137.73 19.12,137.73 19,137.86 U6.5
  INNER2 w0.102: 38.32,122.2 v1(38.9,122.2)
  INNER2 w0.127: v2(23.83,120.97) 24.03,121.17 26.08,121.17 27.11,122.2 38.32,122.2
DIFF1-: length 50.2
  TOP w0.102: U1.D14 v1(40.9,122.2)
  TOP w0.127: U6.6 19,137.36 19.12,137.48 19.46,137.48 20.85,136.09 20.85,133.85 22.35,132.35 22.35,123.05 23.3,122.1 23.3,121.48 23.3,121.25 v2(23.02,120.97) 23.03,120.97 23.4,120.6 23.4,117.76 19.6,113.97 19.12,113.97 19,114.09 U8.19
  INNER2 w0.102: 38.32,122.58 39.06,122.58 39.28,122.36 39.28,121.92 39.45,121.75 40.45,121.75 v1(40.9,122.2)
  INNER2 w0.127: 38.32,122.58 38.19,122.45 27,122.45 25.97,121.42 24.18,121.42 24.07,121.54 23.59,121.54 23.48,121.42 23.47,121.42 v2(23.02,120.97)
DQ0: length 4.1
  TOP w0.2: U38.12 82.73,51.35 82.73,51.35
DQ1: length 4.1
  TOP w0.2: U38.13 82.73,52.62 82.73,52.62
DQ2: length 4.1
  TOP w0.2: U38.14 78.6,53.89 82.73,53.89
DQ3: length 4.1
  TOP w0.2: 82.73,55.16 78.6,55.16 U38.15
DQ4: length 4.1
  TOP w0.2: 82.73,56.43 82.73,56.43 U38.16
DQ5: length 4.1
  TOP w0.2: 82.73,57.7 78.6,57.7 U38.17
DQ6: length 4.1
  TOP w0.2: U38.18 82.73,58.97 82.73,58.97
DQ7: length 4.1
  TOP w0.2: U38.19 78.6,60.24 82.73,60.24
DQ8: length 4.1
  TOP w0.2: 82.73,66.83 82.73,66.83 U39.12
DQ9: length 4.1
  TOP w0.2: U39.13 78.6,68.1 82.73,68.1
DQ10: length 4.1
  TOP w0.2: U39.14 82.73,69.37 82.73,69.37
DQ11: length 4.1
  TOP w0.2: U39.15 78.6,70.64 82.73,70.64
DQ12: length 4.1
  TOP w0.2: 82.73,71.91 82.73,71.91 U39.16
DQ13: length 4.1
  TOP w0.2: 82.73,73.18 78.6,73.18 U39.17
DQ14: length 4.1
  TOP w0.2: 82.73,74.45 82.73,74.45 U39.18
DQ15: length 4.1
  TOP w0.2: 82.73,75.72 78.6,75.72 U39.19
E: length 178.5
  TOP w0.1: U1.C1 v1(54.88,122.18)
  INNER1 w0.1: 38.32,129.09 38.8,128.6 40.95,128.6 42.7,126.85 45.95,126.85 46.57,126.23 46.57,124.08 47.95,122.7 52.65,122.7 53.51,121.84 54.54,121.84 v1(54.88,122.18)
  INNER1 w0.2: 52.9,164.05 52.9,162.8 52.3,162.2 35.45,162.2 31.05,157.8 31.05,153 27.7,149.65 27.7,134.98 33.43,129.25 33.45,129.25 33.61,129.09 38.32,129.09
  INNER1 w0.4: 52.9,164.05 52.9,207.2 ; 93.1,215.6 83.95,215.6 82.91,216.64 57.44,216.64 56.4,215.6 51.6,215.6
  INNER2 w0.4: 52.9,207.2 52.9,214.3 51.6,215.6
FPGA/: length 21.8
  TOP w0.2: U48.5 16.64,67.55 19.35,67.55 21.3,69.5 21.3,80.7 22.13,81.53 U7.15
GAIN: length 124
  TOP w0.102: U1.J4 v1(51.9,128.2)
  TOP w0.2: 95.45,75.42 95.49,75.45 v2(97.3,75.45) 97.9,76.05 97.9,80.1 v2(97.85,80.15) ; v2(97.4,60.3) 97.04,59.94 95.45,59.94
  INNER1 w0.102: v1(51.9,128.2) 52.3,127.8 55.27,127.8 55.42,127.95 55.59,127.95
  INNER1 w0.2: 55.59,127.95 59.32,127.95 60.42,126.85 62.73,126.85 62.78,126.8 63.62,126.8 63.66,126.85 69.59,126.85 71.3,125.14 71.3,124.57 75.37,120.5 97.37,120.5 101.81,116.06 101.81,106.74 100.9,105.84 100.9,95.92 102,94.82 103.25,93.56 103.25,84.7 103.85,84.09 103.85,81.81 102.1,80.05 97.95,80.05 v2(97.85,80.15) ; v2(97.4,60.3) 97.1,60.3 96.15,61.25 96.15,74.3 v2(97.3,75.45)
HS/: length 21.6
  TOP w0.2: U48.4 19.33,68.83 20.9,70.4 20.9,81.35 22.35,82.8 U7.16
JTAG_D0: length 43.7
  TOP w0.102: U2.E14 v1(65.25,100.15)
  BOTTOM w0.1: 61.87,87.5 60.85,88.52
  BOTTOM w0.102: v1(65.25,100.15) 65.35,100.05 65.35,97.97 65.05,97.67 65.05,93.5 64.35,92.8 62.25,92.8 61.87,92.42 61.87,91.82 61.6,91.55 61,91.55 60.85,91.4 60.85,88.52
  BOTTOM w0.2: P1.8 43.97,79.85 48.15,79.85 49,80.7 49,81.85 49.58,82.43 57.22,82.43 57.65,82.86 59.91,82.86 60.85,83.8 61.87,83.8 62.75,84.68 62.75,86.28 62.75,86.28 62.75,86.62 61.87,87.5
LED1: length 1.7
  TOP w0.2: Q4.1 117.65,101.86 117.64,101.85 R31.2
LED2: length 1.7
  TOP w0.2: R32.2 117.64,95.72 117.65,95.73 Q5.1
LED3: length 1.7
  TOP w0.2: R33.2 117.64,89.59 117.65,89.6 Q6.1
LED4: length 1.7
  TOP w0.2: R34.2 117.64,83.46 117.65,83.47 Q7.1
LPF_OUT: length 4.7
  TOP w0.5: R17.2 94.47,124.92 C42.1 91.97,124.92 R18.2
MEMORY.CTRL.RCS0: length 85.2
  TOP w0.102: U1.J1 v1(53.9,128.2)
  TOP w0.2: U40.22 38.21,149.23 v2(36.22,149.23) ; U44.22 v2(80.25,149.22)
  INNER2 w0.2: v2(80.25,149.22) 75.07,149.22 73.1,147.25 58.35,147.25 57,148.59 50,148.59 49.38,149.23 v2(36.22,149.23)
  BOTTOM w0.1: v1(53.9,128.2) 53.9,128.75 52.83,129.82 52.83,129.82 52.72,129.93 52.72,130.88 51.77,131.82 50.74,131.82 50.52,132.04 50.52,133.36 50.65,133.49 50.65,136.01
  BOTTOM w0.2: 50.65,136.01 50.65,136.75 48.5,138.9 43.75,138.9 42.85,139.8 J7.26 42.85,148.45 42.1,149.2 36.25,149.2 v2(36.22,149.23)
MEMORY.CTRL.RCS1: length 82.4
  TOP w0.102: U1.G3 v1(52.9,125.2)
  TOP w0.2: U45.22 v2(91.05,149.22) ; U41.22 50.72,149.22 v2(50.75,149.25)
  INNER2 w0.2: v2(50.75,149.25) 57.25,149.25 58.5,148 v2(62.1,148) 64.56,150.47 69.53,150.47 70.2,149.8 74.35,149.8 74.65,150.1 79.45,150.1 79.65,150.3 81.67,150.3 82.39,151.03 89.25,151.03 v2(91.05,149.22)
  BOTTOM w0.1: 51.3,136.01 51.3,135.25 51,134.95 51,133.75 51.3,133.45 51.3,132.55 52.9,130.95 52.9,130 52.92,130 54.2,128.73 54.3,128.63 54.3,127.6 52.9,126.2 v1(52.9,125.2)
  BOTTOM w0.2: 51.3,136.01 51.3,138.5 52.4,139.6 59.95,139.6 61.7,141.35 61.7,142.4 62.35,143.05 62.35,144.45 62,144.8 61.7,144.8 61.45,145.05 J7.76 61.45,147.7 61.78,148.03 62.07,148.03 v2(62.1,148)
MEMORY.CTRL.RCS2: length 109.1
  TOP w0.102: U1.F2 v1(53.9,124.2)
  TOP w0.2: v2(58.2,149.2) 60.02,149.2 U42.22 ; U46.22 v2(101.97,149.22)
  INNER2 w0.2: v2(58.2,149.2) 58.8,148.6 62.05,148.6 64.35,150.9 68.25,150.9 68.6,151.25 68.6,152.15 69,152.55 69.6,152.55 69.95,152.2 69.95,150.75 70.5,150.2 74.1,150.2 74.6,150.7 v2(77.65,150.7) 81.5,150.7 83.2,152.4 87.6,152.4 88.55,151.45 89.7,151.45 91.93,149.22 v2(101.97,149.22)
  BOTTOM w0.1: 51.7,136.01 51.7,135.35 51.2,134.85 51.2,133.85 51.5,133.55 51.5,132.65 53.08,131.07 53.08,130.1 54.5,128.68 54.5,127.5 53.28,126.28 53.28,124.87 53.9,124.25 v1(53.9,124.2)
  BOTTOM w0.2: v2(77.65,150.7) 77.65,147.75 77.4,147.5 76.65,147.5 76.45,147.3 J7.126 76.45,145.11 76.73,144.82 77.24,144.82 77.5,144.56 77.5,142.1 73.95,138.55 70.35,138.55 69.75,139.15 52.6,139.15 51.7,138.25 51.7,136.01
MEMORY.CTRL.RCS3: length 124.5
  TOP w0.102: U1.G6 v1(49.9,125.2)
  TOP w0.2: v2(69.1,149.2) 70.94,149.2 U43.22 ; U47.22 v2(112.77,149.22)
  INNER2 w0.2: v2(69.1,149.2) 74.35,149.2 74.85,149.7 79.75,149.7 79.9,149.85 82.7,149.85 83.15,149.4 84.1,149.4 85.07,150.38 v2(88.47,150.38) 89.03,150.38 90.8,148.6 102.2,148.6 102.22,148.62 102.22,148.62 102.57,148.97 102.57,148.98 102.82,149.22 v2(112.77,149.22)
  BOTTOM w0.1: 52.1,136.01 52.1,135.45 51.4,134.75 51.4,133.91 51.68,133.62 51.68,132.73 53.26,131.14 53.26,130.19 54.7,128.75 54.7,127.4 53.5,126.2 53.5,124.95 53.8,124.65 54.1,124.65 54.3,124.45 54.3,123.9 54.2,123.8 53.65,123.8 52.7,124.75 50.35,124.75 v1(49.9,125.2)
  BOTTOM w0.2: v2(88.47,150.38) 89.05,150.38 90.8,148.62 90.83,148.62 91.45,148 J7.176 91.45,139.65 89.9,138.1 70.23,138.1 69.69,138.65 52.8,138.65 52.1,137.95 52.1,136.01
MEMORY.CTRL.RWE: length 129.7
  TOP w0.102: U1.M11 v1(43.9,131.2)
  TOP w0.2: U47.29 111.39,158.11 110.77,158.74 105.91,158.74 105.28,158.11 U46.29 100.74,158.11 100.12,158.74 94.59,158.74 93.94,158.09 92.8,158.09 U45.29 92.77,158.1 v2(91.05,158.1) 90.6,157.65 89.25,157.65 88.16,158.74 84.13,158.74 83.49,158.09 81.89,158.09 U44.29 81.86,158.1 80.35,158.1 80.15,158.3 v2(77.45,158.3) 77,158.3 76.56,158.74 73.22,158.74 72.57,158.09 70.97,158.09 U43.29 69.84,158.11 69.2,158.75 62.32,158.75 v2(61.66,158.09) 60.06,158.09 U42.29 59.8,158.35 58.53,158.35 58.48,158.4 56.15,158.4 55.6,158.95 54.35,158.95 54.13,158.74 51.39,158.74 50.74,158.09 49.15,158.09 U41.29 46.19,158.11 v2(46.15,158.15) 45.35,158.95 43.38,158.95 43.19,158.75 40.35,158.75 39.69,158.09 38.23,158.09 U40.29
  INNER1 w0.102: v1(43.9,131.2) 43.9,131.66 44.28,132.04 44.28,132.36 44.74,132.82 45.06,132.82 45.46,133.22 45.46,135.79 45.68,136.01
  INNER1 w0.2: 45.68,136.01 45.68,139.98 47.2,141.5 47.2,149.5 45.15,151.55 45.15,157.15 v2(46.15,158.15)
  BOTTOM w0.2: v2(61.66,158.09) 61.75,158 J7.77 ; J7.177 91.75,157.4 v2(91.05,158.1) ; J7.27 43.15,157.35 43.95,158.15 v2(46.15,158.15) ; v2(77.45,158.3) 76.75,157.6 J7.127
MEMORY.RA0: length 131.2
  TOP w0.102: U1.P5 v1(50.9,133.2)
  TOP w0.15: 62.95,147.95 62.18,147.32 61.98,147.32
  TOP w0.2: 61.98,147.32 57.97,147.32 56.95,148.35 55.45,148.35 v2(55.05,147.95) U42.12 51.57,147.95 50.94,147.32 45.5,147.32 44.88,147.95 U41.12 40.2,147.95 39.58,147.32 34.59,147.32 34,147.92 v2(34,147.95) U40.12 ; U47.12 105.99,147.95 105.36,147.32 100.07,147.32 98.9,148.5 98.4,148.5 97.85,147.95 U46.12 95.4,147.95 94.78,147.32 90.88,147.32 89.3,148.9 87.75,148.9 86.8,147.95 U45.12 84.16,147.95 83.53,147.32 79.42,147.32 v2(78.8,147.95) 78.05,147.95 77.3,148.7 76.8,148.7 76.05,147.95 U44.12 73.24,147.95 72.62,147.32 68.53,147.32 v2(67.1,148.75) 65.95,148.75 65.15,147.95 U43.12 62.95,147.95
  INNER1 w0.102: 52.11,136.01 52.11,135.46 50.9,134.25 v1(50.9,133.2)
  INNER1 w0.2: 52.11,136.01 52.11,138.56 53,139.45 53,145.9 v2(55.05,147.95)
  BOTTOM w0.2: J7.101 68.95,153.16 67.1,151.31 v2(67.1,148.75) ; J7.1 34.48,154.35 34.05,153.92 34.05,153.05 34.45,152.65 34.45,148.4 v2(34,147.95) ; v2(55.05,147.95) 55.05,149.85 53.95,150.95 J7.51 ; J7.151 83.95,153.3 82.7,152.05 82.7,149.05 81.6,147.95 v2(78.8,147.95)
MEMORY.RA1: length 118.3
  TOP w0.102: U1.P10 v1(44.9,133.2)
  TOP w0.2: U47.11 105.99,149.22 105.36,148.59 100.26,148.59 99.55,149.3 98.07,149.3 97.99,149.22 U46.11 94.87,149.22 94.25,148.59 90.81,148.59 89.7,149.7 87.15,149.7 86.67,149.22 U45.11 83.92,149.22 v2(83.5,148.8) 83.3,148.59 79.76,148.59 78.7,149.65 76.4,149.65 75.97,149.22 U44.11 73.24,149.22 72.62,148.59 69.44,148.59 v2(69.25,148.4) 69.05,148.4 67.5,149.95 65.7,149.95 64.97,149.22 U43.11 61.87,149.22 61.25,148.59 57.95,148.59 57.33,149.22 U42.11 51.62,149.22 51,148.6 50.29,148.6 50.29,148.59 48.01,148.59 48.01,148.6 v2(46.5,148.6) 45.53,148.6 44.91,149.22 U41.11 40.02,149.22 39.9,149.1 39.88,149.1 39.37,148.59 36.01,148.59 35.85,148.75 v2(32.85,148.75) 32.38,149.22 U40.11
  INNER1 w0.102: 45.28,136.01 45.28,134.04 44.9,133.66 v1(44.9,133.2)
  INNER1 w0.2: 45.28,136.01 45.28,140.18 46.5,141.4 v2(46.5,148.6)
  BOTTOM w0.2: J7.152 84.25,148.05 v2(83.5,148.8) ; J7.102 v2(69.25,148.4) ; J7.2 35.16,146.15 35.09,146.08 33.87,146.08 32.85,147.1 v2(32.85,148.75) ; J7.52 54.25,147.3 53.9,147.65 53.9,148.3 53.6,148.6 v2(46.5,148.6)
MEMORY.RA2: length 119.8
  TOP w0.102: U1.N11 v1(43.9,132.2)
  TOP w0.2: U40.10 32.54,150.49 33.15,151.1 34.38,151.1 v2(35.62,149.87) 39.52,149.87 40.14,150.49 U41.10 44.44,150.49 v2(44.45,150.5) 45.08,149.87 50.85,149.87 51.47,150.49 U42.10 55.31,150.49 v2(55.65,150.15) 55.94,149.87 62.41,149.87 63.04,150.49 U43.10 68.03,150.49 v2(68.65,149.87) 73.27,149.87 73.89,150.49 U44.10 76.06,150.49 76.47,150.07 80.42,150.07 80.65,149.84 83.39,149.84 v2(83.75,150.2) 84.04,150.49 U45.10 87.54,150.49 88.1,151.05 89.6,151.05 90.78,149.87 94.71,149.87 95.34,150.49 U46.10 98.91,150.49 99.7,149.7 99.72,149.7 100.07,149.35 101.25,149.35 101.76,149.87 106.12,149.87 106.74,150.49 U47.10
  INNER1 w0.102: v1(43.9,132.2) 43.9,132.66 44.46,133.22 44.46,136.01
  INNER1 w0.2: 44.46,136.01 44.45,136.03 44.45,142.15 44.76,142.45 44.76,143.28 44.45,143.59 v2(44.45,150.5)
  BOTTOM w0.2: v2(35.62,149.87) 35.3,150.19 35.3,152.65 35.95,153.31 J7.3 ; v2(55.65,150.15) 54.55,151.25 J7.53 ; J7.103 69.55,153.2 68.65,152.3 v2(68.65,149.87) ; v2(83.75,150.2) 83.75,150.9 84.55,151.7 J7.153
MEMORY.RA3: length 132.7
  TOP w0.102: U1.R9 v1(45.9,134.2)
  TOP w0.2: U40.9 32.74,151.76 32.75,151.75 v2(33.35,151.75) 34.02,151.75 ; 34.02,151.75 34.85,151.75 35.47,151.13 39.38,151.13 40.01,151.76 40.14,151.76 40.15,151.75 40.65,151.75 40.66,151.76 U41.9 44.92,151.76 45.53,151.15 v2(47,151.15) 47.95,151.15 47.97,151.13 50.98,151.13 51.61,151.76 U42.9 55.83,151.76 56.46,151.13 62.09,151.13 62.71,151.76 U43.9 68.14,151.76 68.75,151.15 v2(69.3,151.15) 69.31,151.13 72.59,151.13 73.21,151.76 U44.9 74.83,151.7 79.2,151.7 79.77,151.13 83.19,151.13 83.6,151.55 v2(83.6,151.76) U45.9 86.36,151.76 86.85,152.25 87.75,152.25 88.15,151.85 90.05,151.85 90.76,151.13 94.78,151.13 95.41,151.76 U46.9 100.94,151.76 101.56,151.13 105.69,151.13 106.31,151.76 U47.9 ; 34.02,151.75 34,151.76
  INNER1 w0.102: v1(45.9,134.2) 45.9,134.66 46.48,135.24 46.48,136.01
  INNER1 w0.2: v2(47,151.15) 47,150.9 48,149.9 48,141.1 46.48,139.58 46.48,136.01
  BOTTOM w0.2: v2(47,151.15) 50.4,151.15 51.2,150.35 53.95,150.35 54.3,150 54.3,147.85 54.85,147.3 J7.54 ; J7.154 84.85,149.1 84.45,149.5 83.4,149.5 83.1,149.8 83.1,151.26 v2(83.6,151.76) ; v2(69.3,151.15) 69.85,150.6 J7.104 ; J7.4 36.25,147.19 36.14,147.3 36.14,147.3 35.96,147.48 34.67,147.48 34.55,147.35 33.65,147.35 33.35,147.65 33.35,148.4 33.45,148.5 33.45,149.15 32.75,149.85 32.75,151.15 v2(33.35,151.75)
MEMORY.RA4: length 117
  TOP w0.102: U1.P8 v1(47.9,133.2)
  TOP w0.2: U40.8 33.98,153.03 34.61,152.41 v2(35.9,152.41) 39.41,152.41 40.03,153.03 U41.8 42.72,153.03 43.55,152.2 46.45,152.2 v2(46.65,152.4) 51.25,152.4 51.88,153.03 U42.8 54.42,153.03 54.8,152.65 v2(55.4,152.65) 55.7,152.95 57.9,152.95 58.44,152.41 62.16,152.41 62.78,153.03 U43.8 65.53,153.03 65.55,153.05 66.71,153.05 67.16,152.6 68.6,152.6 v2(69.25,151.95) 69.7,152.41 72.15,152.41 72.34,152.6 73.25,152.6 73.68,153.03 U44.8 76.52,153.03 77.15,152.4 83.53,152.4 84.16,153.03 U45.8 87.67,153.03 88.25,152.45 v2(88.8,152.45) 88.84,152.41 94.6,152.41 95.23,153.03 U46.8 98.57,153.03 99.2,152.4 105.36,152.4 105.99,153.03 U47.8
  INNER1 w0.102: 47.59,136.01 47.52,135.94 47.52,134.04 47.9,133.66 v1(47.9,133.2)
  INNER1 w0.2: v2(46.65,152.4) 46.85,152.2 47.4,152.2 48.8,150.8 48.8,137.22 47.59,136.01
  BOTTOM w0.2: v2(69.25,151.95) 70.15,152.85 J7.105 ; v2(35.9,152.41) 36.55,153.06 J7.5 ; v2(55.4,152.65) 55.15,152.9 J7.55 ; v2(88.8,152.45) 88.8,151.8 87.8,150.8 86.35,150.8 85.15,152 J7.155
MEMORY.RA5: length 164.1
  TOP w0.102: U1.R7 v1(48.9,134.2)
  TOP w0.2: U47.7 105.99,154.3 105.36,153.68 100.67,153.68 99.95,154.4 96.7,154.4 U46.7 95.05,154.3 94.43,153.68 88.92,153.68 88.3,154.3 U45.7 84.16,154.3 83.53,153.68 77.18,153.68 76.55,154.3 U44.7 73.65,154.3 73.03,153.68 67.33,153.68 66.71,154.3 U43.7 62.65,154.3 62.02,153.68 58.51,153.68 58.38,153.8 56.15,153.8 55.65,154.3 U42.7 51.5,154.3 50.85,153.65 50.29,153.65 50.29,153.66 47.7,153.66 v2(47.65,153.7) 47.6,153.65 45.53,153.65 44.88,154.3 U41.7 40.1,154.3 39.47,153.68 v2(34.65,153.68) 34.02,154.3 U40.7
  INNER1 w0.1: 49.66,136.01 49.4,135.75 49.4,135.05 48.9,134.55 v1(48.9,134.2)
  INNER1 w0.2: 49.66,136.01 50.25,136.6 50.25,138.85 50.05,139.05 50.05,139.55 v2(50.95,140.45) 50.95,147.4 50,148.35 50,152.4 48.7,153.7 v2(47.65,153.7)
  INNER2 w0.2: v2(55.45,140.45) 56.55,139.35 v2(70.4,139.35) 70.6,139.15 78.4,139.15 v2(78.65,139.4)
  BOTTOM w0.2: v2(34.65,153.68) 34.65,153.1 34.86,152.89 34.86,149.74 35.98,148.62 36.65,148.62 36.85,148.43 J7.6 ; J7.56 v2(55.45,140.45) v2(50.95,140.45) ; v2(78.65,139.4) 80.7,141.45 83.15,141.45 83.75,142.05 83.75,142.3 85,143.55 85,144.16 85.45,144.61 J7.156 ; J7.106 70.45,139.4 v2(70.4,139.35)
MEMORY.RA6: length 145.7
  TOP w0.102: U1.P6 v1(49.9,133.2)
  TOP w0.2: U40.6 v2(34,155.57) 34.62,154.94 39.55,154.94 40.17,155.57 U41.6 45.23,155.57 45.86,154.94 50.79,154.94 51.42,155.57 U42.6 54.57,155.57 v2(55,156) 55.95,156 57,154.94 62.09,154.94 62.72,155.57 U43.6 66.92,155.57 67.25,155.9 v2(67.85,155.9) 68.81,154.94 72.94,154.94 73.57,155.57 U44.6 76.53,155.57 77.15,154.94 79.84,154.94 79.85,154.95 80.7,154.95 80.71,154.94 83.53,154.94 84.16,155.57 U45.6 88.23,155.57 88.86,154.94 94.25,154.94 94.85,155.55 96.58,155.55 U46.6 100.08,155.57 100.7,154.95 v2(100.85,154.95) 100.85,154.94 105.36,154.94 105.99,155.57 U47.6
  INNER1 w0.1: 51.05,136.01 51.05,135.55 50.35,134.85 50.35,133.75 49.9,133.3 v1(49.9,133.2)
  INNER1 w0.2: 51.05,136.01 51.05,138.85 51.15,138.95 51.15,138.97 52,139.81 52,140.95 51.8,141.15 51.8,154.55 53.25,156 v2(55,156) ; v2(87.95,162.05) 88.5,162.05 89,161.55 89,160.75 89.4,160.35 97.9,160.35 99.9,158.35 99.9,155.85 100.8,154.95 v2(100.85,154.95)
  BOTTOM w0.2: v2(34,155.57) 34.33,155.9 35.35,155.9 35.45,155.8 35.95,155.8 36.05,155.9 36.64,155.9 37.15,155.39 J7.7 ; J7.107 70.75,155.45 70.5,155.7 68.05,155.7 v2(67.85,155.9) ; J7.57 55.75,155.6 55.35,156 v2(55,156) ; v2(87.95,162.05) 86.5,162.05 85.75,161.3 J7.157
MEMORY.RA7: length 183.7
  TOP w0.102: U1.N5 v1(50.9,132.2)
  TOP w0.2: U47.5 105.99,156.84 105.36,156.22 100.69,156.22 100.06,156.84 U46.5 94.86,156.84 94.85,156.85 94.6,156.85 93.97,156.22 88.84,156.22 88.21,156.84 U45.5 84.16,156.84 83.53,156.22 80.73,156.22 80.37,155.85 77.45,155.85 76.46,156.84 U44.5 73.64,156.84 73.02,156.22 69.63,156.22 68.95,156.9 63.91,156.9 U43.5 62.44,156.84 61.8,156.2 58.9,156.2 58.88,156.22 57.24,156.22 56.25,157.2 54.82,157.2 54.77,157.24 v2(54.76,157.24) 54.44,157.24 54.04,156.84 U42.5 51.42,156.84 50.79,156.22 45.94,156.22 45.4,156.75 42.12,156.75 U41.5 40.24,156.84 39.61,156.22 36.83,156.22 36.05,157 35.3,157 35.14,156.84 v2(32.91,156.84) U40.5
  INNER1 w0.102: v1(50.9,132.2) 50.45,132.65 50.45,133.45 50.65,133.65 50.65,134.55 51.55,135.45
  INNER1 w0.2: 51.55,135.45 51.55,138.8 52.4,139.65 v2(52.4,141.45) 52.4,141.5 52.6,141.7 52.6,153.95 52.8,154.15 55.3,154.15 56.3,155.15 56.3,156.85 55.91,157.24 v2(54.76,157.24)
  INNER2 w0.2: v2(80.15,139.95) 79.55,139.95 79.35,140.15 77,140.15 76.4,139.55 71.3,139.55 v2(71.1,139.75) 70.9,139.95 70.15,139.95 69.95,139.75 57.35,139.75 v2(56.05,141.05) 55.2,141.05 55,140.85 53.05,140.85 52.45,141.45 v2(52.4,141.45)
  BOTTOM w0.2: v2(32.91,156.84) 30.75,154.68 30.75,145.6 31.7,144.65 35.85,144.65 35.95,144.75 37.09,144.75 37.45,145.11 J7.8 ; v2(80.15,139.95) 81.25,141.05 83.35,141.05 83.75,141.45 84.6,141.45 84.95,141.8 84.95,142.85 85.4,143.3 85.4,144 86.05,144.65 J7.158 ; J7.58 56.05,144.9 55.85,144.7 55.85,141.25 v2(56.05,141.05) ; v2(71.1,139.75) 71.05,139.8 J7.108
MEMORY.RA8: length 126.2
  TOP w0.102: U1.L8 v1(47.9,130.2)
  TOP w0.2: U47.27 111.38,155.57 110.75,156.19 105.91,156.19 105.53,155.81 105.51,155.81 105.27,155.57 U46.27 100.68,155.57 100.06,156.19 94.64,156.19 93.99,155.55 92.8,155.55 U45.27 88.83,155.57 88.2,156.2 v2(87.35,156.2) 84.14,156.2 83.49,155.55 81.89,155.55 U44.27 80.75,155.57 80.63,155.45 77.25,155.45 76.5,156.2 73.6,156.2 72.95,155.55 70.97,155.55 U43.27 69.43,155.57 v2(68.7,156.3) 68.5,156.5 65.4,156.5 65.1,156.2 62.7,156.2 62.05,155.55 60.06,155.55 U42.27 57.28,155.57 56.25,156.6 v2(55.7,156.6) 54.6,156.6 54.2,156.19 51.39,156.19 50.74,155.55 49.15,155.55 U41.27 47.48,155.57 v2(47.45,155.6) 45.85,155.6 45.25,156.19 40.2,156.19 39.55,155.55 38.23,155.55 U40.27 36.83,155.57 36,156.4 v2(35.7,156.4)
  INNER1 w0.102: 47.1,136.01 47.1,133.15 47.52,132.73 47.52,131.04 47.9,130.66 v1(47.9,130.2)
  INNER1 w0.2: 47.1,136.01 47.1,136.09 48.4,137.39 48.4,150.6 47.24,151.75 46.35,151.75 46.05,152.06 46.05,154.35 47.3,155.6 v2(47.45,155.6)
  BOTTOM w0.2: v2(35.7,156.4) 37.35,156.4 37.75,156 J7.9 ; J7.159 86.35,155.85 86.7,156.2 v2(87.35,156.2) ; v2(55.7,156.6) 55.7,156.55 56.35,155.9 J7.59 ; J7.109 71.35,155.9 71.05,156.2 68.85,156.2 68.8,156.25 68.75,156.25 v2(68.7,156.3)
MEMORY.RA9: length 209.1
  TOP w0.102: U1.M6 v1(49.9,131.2)
  TOP w0.2: U47.26 111.35,154.3 v2(110.73,154.93) 106.02,154.93 105.4,154.3 U46.26 100.65,154.3 100.03,154.93 94.79,154.93 94.15,154.28 92.8,154.28 U45.26 88.9,154.3 88.28,154.93 84.13,154.93 83.49,154.28 81.89,154.28 U44.26 77.2,154.3 76.56,154.94 73.55,154.94 72.88,154.28 70.97,154.28 U43.26 67.34,154.3 66.71,154.93 62.67,154.93 62.03,154.28 60.06,154.28 U42.26 56.7,154.3 56.05,154.95 54.1,154.95 54.1,154.94 51.39,154.94 50.73,154.28 49.15,154.28 U41.26 45.51,154.3 44.88,154.93 40.13,154.93 39.48,154.28 38.23,154.28 U40.26 ; v2(38.95,140.15) 48.6,140.15 50.5,142.05 53,142.05 v2(53.6,141.45)
  INNER1 w0.1: v1(49.9,131.2) 50.55,131.2 51.5,132.15 51.5,134.4 52.76,135.66 52.76,136.01
  INNER1 w0.2: v2(53.6,141.45) 53.6,139.4 52.76,138.56 52.76,136.01 ; v2(110.25,141.55) 110.25,154.45 v2(110.73,154.93)
  INNER2 w0.2: v2(110.25,141.55) 94.25,141.55 93.15,140.45 v2(81.6,140.45) 81,140.45 80.9,140.55 76.8,140.55 76.2,139.95 72.05,139.95 v2(71.65,140.35) 57.65,140.35 v2(57,141) 56.95,141 56.3,141.65 55.8,141.65 55.6,141.45 v2(53.6,141.45)
  BOTTOM w0.2: J7.160 86.65,144.68 85.8,143.83 85.8,142 84.25,140.45 v2(81.6,140.45) ; v2(57,141) 56.25,141.75 56.25,144.5 56.65,144.9 J7.60 ; J7.10 38.05,145.11 37.77,144.82 37.76,144.82 37.15,144.22 37.15,140.75 37.75,140.15 v2(38.95,140.15) ; J7.110 v2(71.65,140.35)
MEMORY.RA10: length 115.3
  TOP w0.102: U1.T10 v1(44.9,135.2)
  TOP w0.2: v2(36.5,150.5) 38.2,150.5 U40.23 38.23,150.47 39.37,150.47 40.02,151.12 44.78,151.12 45.35,150.55 v2(45.35,150.5) 46.51,150.5 46.52,150.49 U41.23 49.15,150.47 50.89,150.47 51.53,151.12 55.8,151.12 56.41,150.5 v2(56.7,150.5) 60.03,150.5 U42.23 62.04,150.49 62.66,151.12 68.13,151.12 68.76,150.49 U43.23 72.79,150.49 v2(73.1,150.8) 73.41,151.12 76.38,151.12 76.57,151.3 78.9,151.3 79.71,150.49 U44.23 81.89,150.47 83.17,150.47 83.81,151.12 86.91,151.12 v2(87.42,151.62) 87.6,151.45 89.8,151.45 90.76,150.49 U45.23 92.8,150.47 94.72,150.47 95.37,151.12 100.84,151.12 101.45,150.5 103.69,150.5 U46.23 105.69,150.49 106.31,151.12 110.73,151.12 111.36,150.49 U47.23
  INNER1 w0.102: 44.88,136.01 44.9,135.99 v1(44.9,135.2)
  INNER1 w0.2: 44.88,136.01 44.88,140.38 45.25,140.75 45.25,150.4 v2(45.35,150.5)
  BOTTOM w0.2: J7.111 71.95,153.25 72.25,152.95 73.25,152.95 73.5,152.7 73.5,151.2 v2(73.1,150.8) ; v2(36.5,150.5) 38.35,152.35 J7.11 ; J7.61 56.95,153.15 56.4,152.6 56.4,150.8 v2(56.7,150.5) ; v2(87.42,151.62) 86.95,152.1 J7.161
MEMORY.RA11: length 176.4
  TOP w0.102: U1.P11 v1(43.9,133.2)
  TOP w0.2: v2(38.55,140.95) 43.05,140.95 v2(43.7,141.6) ; U40.25 38.23,153.01 39.41,153.01 40.06,153.66 43.59,153.66 43.85,153.4 v2(43.85,152.8) 46.2,152.8 46.4,153 46.45,153 46.48,153.03 U41.25 49.15,153.01 51.11,153.01 51.75,153.66 55.3,153.66 55.55,153.4 58.21,153.4 58.59,153.03 U42.25 60.06,153.01 62.01,153.01 62.66,153.66 66.71,153.66 67.34,153.03 U43.25 70.97,153.01 72.96,153.01 73.6,153.66 76.55,153.66 77.17,153.03 U44.25 81.89,153.01 83.49,153.01 84.13,153.66 88.34,153.66 88.97,153.03 91.03,153.03 91.03,153.03 U45.25 92.8,153.01 94.62,153.01 95.26,153.66 97.96,153.66 98.3,154 99.65,154 100.62,153.03 U46.25 105.28,153.03 105.91,153.66 110.69,153.66 111.32,153.03 U47.25
  INNER1 w0.102: v1(43.9,133.2) 43.9,133.66 44.28,134.04 44.28,135.36 43.9,135.74 43.9,136.01
  INNER1 w0.2: 43.9,136.01 43.9,141.4 v2(43.7,141.6) 43.85,141.75 43.85,142.11 44.36,142.62 44.36,143.12 43.85,143.63 43.85,147.41 42.93,148.33 42.93,148.82 43.85,149.75 v2(43.85,152.8)
  INNER2 w0.2: v2(43.7,141.6) 44.05,141.25 49.6,141.25 50.4,142.05 53.85,142.05 54.05,141.85 55.44,141.85 55.63,142.05 56.8,142.05 57.77,141.08 v2(57.82,141.08) 57.95,140.95 72.6,140.95 v2(72.85,141.2) 73.7,140.35 75.95,140.35 76.65,141.05 86.65,141.05 v2(86.8,141.2)
  BOTTOM w0.2: J7.12 38.65,145.11 37.55,144.01 37.55,141.35 37.95,140.95 v2(38.55,140.95) ; J7.62 57.25,144.9 56.65,144.3 56.65,142.25 v2(57.82,141.08) ; J7.162 87.25,144.72 86.2,143.67 86.2,141.8 v2(86.8,141.2) ; v2(72.85,141.2) 72.25,141.8 J7.112
MEMORY.RA12: length 123.4
  TOP w0.102: U1.T9 v1(45.9,135.2)
  TOP w0.2: U40.4 33.96,158.11 34.57,157.5 v2(36.55,157.5) 36.56,157.49 39.69,157.49 40.31,158.11 U41.4 43.11,158.11 43.5,158.5 44.95,158.5 45.95,157.5 v2(46.8,157.5) 46.81,157.49 50.79,157.49 51.42,158.11 U42.4 54.06,158.11 54.26,158.31 v2(55.39,158.31) 55.7,158 58.31,158 58.37,157.95 58.38,157.95 58.85,157.49 61.9,157.49 62.53,158.11 U43.4 65.11,158.11 65.35,158.35 68.9,158.35 69.77,157.49 72.48,157.49 v2(72.55,157.42) 73.24,158.11 U44.4 76.49,158.11 77,157.6 80.28,157.6 80.4,157.49 83.53,157.49 84.16,158.11 U45.4 v2(87.55,158.11) 88.14,158.11 88.76,157.49 89,157.25 91.26,157.25 91.5,157.49 93.98,157.49 94.61,158.11 U46.4 100.09,158.11 100.71,157.49 105.36,157.49 105.99,158.11 U47.4
  INNER1 w0.102: 46.08,136.01 45.9,135.83 v1(45.9,135.2)
  INNER1 w0.2: 46.08,136.01 46.08,139.78 47.6,141.3 47.6,149.7 45.65,151.65 45.65,156.35 v2(46.8,157.5)
  BOTTOM w0.2: v2(55.39,158.31) 55.45,158.25 55.45,158.25 55.5,158.2 55.5,158.15 56.35,157.3 56.35,156.5 57.17,155.68 57.27,155.68 57.55,155.39 J7.63 ; J7.13 38.95,157.15 38.65,157.45 36.6,157.45 v2(36.55,157.5) ; v2(87.55,158.11) 87.55,156.85 87.95,156.45 87.95,155.95 87.55,155.55 J7.163 ; J7.113 v2(72.55,157.42)
MEMORY.RA13: length 178.1
  TOP w0.102: U1.T8 v1(47.9,135.2)
  TOP w0.2: U47.28 111.41,156.84 110.79,157.47 105.97,157.47 105.34,156.84 U46.28 100.71,156.84 100.09,157.47 94.61,157.47 93.96,156.82 92.8,156.82 U45.28 92.77,156.85 88.8,156.85 88.16,157.49 84.15,157.49 83.49,156.82 81.89,156.82 U44.28 80.64,156.84 80.05,156.25 77.65,156.25 76.44,157.47 73.52,157.47 72.85,156.8 71,156.8 U43.28 69.61,156.84 68.99,157.47 62.45,157.47 61.81,156.82 61.37,156.82 60.06,156.82 U42.28 58.91,156.84 58.15,157.6 55.27,157.6 55.12,157.75 55.1,157.75 54.95,157.9 54.52,157.9 54.1,157.49 51.41,157.49 50.74,156.82 49.15,156.82 U41.28 47.36,156.84 v2(47.35,156.85) 45.95,156.85 44.85,157.95 43.65,157.95 43.19,157.49 40.28,157.49 39.62,156.82 38.23,156.82 U40.28
  INNER1 w0.102: 48.16,136.01 47.9,135.76 v1(47.9,135.2)
  INNER1 w0.2: v2(47.35,156.85) 47.78,156.42 47.78,156.37 48.05,156.1 48.05,155.05 47.75,154.75 47.1,154.75 46.6,154.25 46.6,153.3 47.3,152.6 47.6,152.6 49.2,151 49.2,142.1 v2(49.4,141.9) 49.2,141.7 49.2,137.06 48.16,136.01
  INNER2 w0.2: v2(86.8,142.05) 86.2,141.45 76.45,141.45 75.75,140.75 74.15,140.75 v2(72.85,142.05) 72.8,142.05 72.1,141.35 58.4,141.35 v2(57.85,141.9) 57.7,142.05 57.42,142.33 57.3,142.45 55.47,142.45 55.27,142.25 54.22,142.25 54.02,142.45 49.95,142.45 v2(49.4,141.9) 49.15,141.65 45.25,141.65 44.65,142.25 43.5,142.25 43.1,141.85 43.1,141.7 42.45,141.05 41.4,141.05 40.2,142.25 38.7,142.25 38.35,141.9 38.35,141.85 v2(38.15,141.65)
  BOTTOM w0.2: v2(57.85,141.9) 57.05,142.7 57.05,144.1 57.85,144.9 J7.64 ; v2(38.15,141.65) 38.15,144.01 39.25,145.11 J7.14 ; v2(86.8,142.05) 86.8,143.7 87.85,144.75 J7.164 ; v2(72.85,142.05) J7.114
MEMORY.RA14: length 128.8
  TOP w0.102: U1.T7 v1(48.9,135.2)
  TOP w0.2: U40.3 33.98,159.38 34.61,158.75 39.45,158.75 v2(39.92,159.23) 40.08,159.38 U41.3 45.87,159.38 46.5,158.75 v2(47.4,158.75) 50.79,158.75 51.42,159.38 U42.3 56.02,159.38 v2(56.2,159.2) 56.6,158.8 58.65,158.8 58.69,158.75 61.2,158.75 61.83,159.38 U43.3 69.17,159.38 69.8,158.75 72.25,158.75 v2(72.85,159.35) 72.88,159.38 U44.3 77.64,159.38 78.27,158.75 83.53,158.75 84.16,159.38 U45.3 85.71,159.35 v2(88.15,159.35) 88.6,158.9 90.05,158.9 90.2,158.75 93.96,158.75 94.58,159.38 U46.3 100.07,159.38 100.7,158.75 105.36,158.75 105.99,159.38 U47.3
  INNER1 w0.102: 48.9,136.01 v1(48.9,135.2)
  INNER1 w0.2: 48.9,136.01 48.9,136.19 49.6,136.89 49.6,141.25 50,141.65 50,142.25 49.6,142.65 49.6,151.25 47.75,153.1 47.4,153.1 47.02,153.48 47.02,154.03 47.3,154.3 48.05,154.3 48.48,154.73 48.48,157.67 v2(47.4,158.75)
  BOTTOM w0.2: J7.65 58.15,155.55 57.95,155.75 57.76,155.75 57.43,156.07 57.38,156.07 56.8,156.65 56.8,158.6 v2(56.2,159.2) ; v2(72.85,159.35) 73.15,159.05 J7.115 ; J7.165 88.15,155.55 88.35,155.75 88.35,159.15 v2(88.15,159.35) ; v2(39.92,159.23) 39.92,157.53 39.55,157.15 J7.15
MEMORY.RA15: length 191
  TOP w0.102: U1.T6 v1(49.9,135.2)
  TOP w0.2: U47.31 111.35,160.65 110.73,161.28 105.68,161.28 105.05,160.65 U46.31 100.08,160.65 99.46,161.28 95.04,161.28 94.4,160.63 92.8,160.63 U45.31 89.17,160.65 88.52,161.3 v2(87.55,161.3) 86.85,161.3 86.82,161.28 84.13,161.28 83.49,160.63 81.89,160.63 U44.31 78.25,160.65 77.65,161.25 76.6,161.25 76.56,161.3 72.75,161.3 72.08,160.63 70.97,160.63 U43.31 67.34,160.65 66.71,161.28 62.3,161.28 61.66,160.63 60.06,160.63 U42.31 56.9,160.65 56.25,161.3 v2(55.45,161.3) 54.1,161.3 54.1,161.3 51.41,161.3 50.74,160.63 49.15,160.63 U41.31 45.51,160.65 44.88,161.28 40.47,161.28 39.83,160.63 38.23,160.63 U40.31
  INNER1 w0.102: v1(49.9,135.2) 49.9,135.49 50.42,136.01
  INNER1 w0.2: v2(87.55,161.3) 87.2,160.95 87.2,159.45 88.15,158.5 88.15,150.95 87.75,150.55 87.75,147.6 88.3,147.05 v2(88.3,142.85) ; 50.42,136.01 50.65,136.24 v2(50.65,139.3) 51.55,140.2 51.55,140.7 51.35,140.9 51.35,155.55 55.45,159.65 v2(55.45,161.3)
  INNER2 w0.2: v2(88.3,142.85) 87.68,143.47 80.72,143.47 79.9,142.65 74.35,142.65 v2(73.75,142.05) 73.15,142.65 70.25,142.65 69.4,143.5 60.3,143.5 v2(58.75,141.95) ; v2(38.95,141.65) 40.2,141.65 41.35,140.5 49.45,140.5 v2(50.65,139.3)
  BOTTOM w0.2: v2(58.75,141.95) 58.2,142.5 57.85,142.5 57.45,142.9 57.45,143.9 58.45,144.9 J7.66 ; v2(88.3,142.85) 88.45,143 J7.166 ; v2(38.95,141.65) 38.95,144 39.85,144.9 J7.16 ; v2(73.75,142.05) 73.45,142.35 J7.116
MEMORY.RA16: length 106.4
  TOP w0.2: U47.2 106,160.65 105.38,160.03 100.07,160.03 99.45,160.65 U46.2 95.07,160.65 94.45,160.03 90.77,160.03 90.6,160.2 88.98,160.2 88.53,160.65 v2(88.15,160.65) U45.2 84.16,160.65 83.53,160.03 78.25,160.03 77.62,160.65 U44.2 v2(73.05,160.65) 72.41,160 67.91,160 67.9,160 67.36,160 66.71,160.65 U43.2 62.33,160.65 61.7,160.03 v2(56.42,160.03) 55.33,160.03 54.7,160.65 U42.2 51.42,160.65 50.79,160.03 45.5,160.03 44.88,160.65 U41.2 40.5,160.65 v2(39.88,160.03) 34.59,160.03 33.96,160.65 U40.2
  BOTTOM w0.2: v2(56.42,160.03) 57.2,159.24 57.2,156.85 57.57,156.48 57.6,156.48 57.72,156.35 58.4,156.35 58.75,156 J7.67 ; J7.17 40.15,157.05 40.55,157.45 40.55,159.5 40.02,160.03 v2(39.88,160.03) ; v2(88.15,160.65) 88.75,160.05 J7.167 ; J7.117 73.75,159.95 v2(73.05,160.65)
MEMORY.RD0: length 445.8
  TOP w0.102: U1.R15 v1(39.9,134.2)
  TOP w0.2: v2(29.12,146.68) U40.13 32.67,146.68 33.3,146.05 39.5,146.05 40.13,146.68 U41.13 44.9,146.68 45.52,146.06 50.95,146.06 51.58,146.68 U42.13 55.81,146.68 56.44,146.06 61.91,146.06 62.35,146.5 63.67,146.5 U43.13 66.73,146.68 67.35,146.06 72.62,146.06 73.24,146.68 U44.13 77.47,146.68 78.09,146.06 83.53,146.06 84.16,146.68 U45.13 86.83,146.68 88.05,147.9 v2(88.35,147.9) 88.55,147.9 90.4,146.06 94.81,146.06 95.43,146.68 U46.13 99.47,146.68 100.09,146.06 105.36,146.06 105.99,146.68 U47.13 110.63,146.68 111.26,146.06 119.31,146.06 v2(122.27,149.02)
  INNER1 w0.102: 39.35,136.01 39.35,134.75 v1(39.9,134.2)
  INNER1 w0.2: 55,164.05 55,163 53,161 35.95,161 32.25,157.3 32.25,152.5 29.12,149.37 v2(29.12,146.68) 29.7,146.1 29.7,141.15 33,137.85 38.35,137.85 39.35,136.85 39.35,136.01 ; v2(88.35,147.9) 89,147.25 89,142.6 88.65,142.25 87.85,142.25 87.4,142.7 77.65,142.7 76.9,141.95 v2(74.6,141.95) 74.6,142.05 74,142.65 72.3,142.65 71.05,141.4 60.25,141.4 v2(59.65,142) ; 132.15,149.02 v2(122.27,149.02)
  INNER1 w0.4: 55,164.05 55,207.2 ; 132.15,149.02 161,149.02 arc(168.57,145.89) 171.7,138.32 171.7,127.6 arc(168.57,120.03) 161,116.9 157.65,116.9 arc(152.49,114.76) 150.35,109.6 150.35,75.1 150.75,74.7 150.75,72.6 ; 51.6,213.06 54.34,213.06 54.35,213.05 56.55,213.05 57.6,214.1 82.9,214.1 83.94,213.06 93.1,213.06
  INNER2 w0.4: 55,207.2 55,213.05
  BOTTOM w0.1: 39.58,136.01 39.58,134.52 v1(39.9,134.2)
  BOTTOM w0.2: v2(59.65,142) 58.75,142.9 58.25,142.9 57.9,143.25 57.9,143.75 59.05,144.9 J7.68 ; v2(74.6,141.95) 74.6,142.05 74.05,142.6 J7.118 ; v2(88.35,147.9) 89.05,147.2 J7.168 ; J7.18 40.45,144.94 39.58,144.07 39.58,136.01
MEMORY.RD1: length 456
  TOP w0.102: U1.R16 v1(38.9,134.2)
  TOP w0.2: v2(122.41,147.02) 120.15,144.76 111.3,144.76 110.66,145.41 U47.14 105.99,145.41 105.36,144.78 v2(102.15,144.78) 100.11,144.78 99.49,145.41 U46.14 95.36,145.41 94.73,144.78 89.2,144.78 88.57,145.41 U45.14 84.51,145.41 83.88,144.78 77.91,144.78 77.29,145.41 U44.14 73.24,145.41 72.62,144.78 67.37,144.78 66.75,145.41 U43.14 62.66,145.41 62.03,144.78 56.34,144.78 55.72,145.41 U42.14 51.51,145.41 50.88,144.78 45.54,144.78 44.92,145.41 U41.14 40.11,145.41 39.48,144.78 33.27,144.78 32.64,145.41 U40.14 29.11,145.41 v2(29.1,145.4)
  INNER1 w0.102: v1(38.9,134.2) 38.52,134.58 38.52,135.98 38.55,136.01
  INNER1 w0.2: v2(66.1,160.05) 63.2,160.05 59.9,163.35 59.9,164.05 ; 38.55,136.01 38.55,137.05 38.15,137.45 32.75,137.45 29.1,141.1 v2(29.1,145.4) ; 132.15,147.02 v2(122.41,147.02)
  INNER1 w0.4: 59.9,164.05 59.9,207.2 ; 132.15,147.02 161,147.02 arc(167.15,144.47) 169.7,138.32 169.7,127.6 arc(167.15,121.45) 161,118.9 157.65,118.9 arc(151.07,116.18) 148.35,109.6 148.35,75.1 148.3,75.05 148.3,72.6 ; 61.1,213.06 57.86,213.06 56.82,212.02 29.48,212.02 28.44,213.06 19.6,213.06
  INNER2 w0.2: v2(90.1,159.5) 88.95,159.5 88.45,160 87.7,160 87.3,160.4 80.1,160.4 79.2,161.3 v2(78.55,161.3) 78.12,160.88 74.32,160.88 73.5,160.05 v2(66.1,160.05) 57.6,160.05 56.8,159.25 56.8,152.55 57,152.35 v2(57,151.75) 53.75,151.75 53.15,151.15 49.3,151.15 48.65,151.8 40.95,151.8 v2(40.4,152.35)
  INNER2 w0.4: 59.9,207.2 59.9,211.86 61.1,213.06
  BOTTOM w0.2: J7.19 40.75,152.7 v2(40.4,152.35) ; J7.169 89.35,156.75 89.2,156.9 89.2,158.6 v2(90.1,159.5) 91.13,159.5 98.45,159.5 100.15,157.8 100.15,151.85 99.45,151.15 99.45,149.08 102.15,146.38 v2(102.15,144.78) ; v2(57,151.75) 57,152.55 57.4,152.95 59.15,152.95 59.35,153.15 J7.69 ; J7.119 74.35,158.75 76.9,161.3 v2(78.55,161.3)
MEMORY.RD2: length 371.4
  TOP w0.102: U1.R14 v1(40.9,134.2)
  TOP w0.2: v2(122.62,145.02) 121.12,143.51 111.25,143.51 110.63,144.14 U47.15 105.99,144.14 105.36,143.51 100.09,143.51 99.46,144.14 U46.15 95.34,144.14 94.7,143.5 v2(89.65,143.5) 89.19,143.5 88.55,144.14 U45.15 84.54,144.14 83.9,143.5 78,143.5 77.9,143.4 v2(76.9,143.4) 76.7,143.4 75.96,144.14 U44.15 73.19,144.14 72.55,143.5 67.36,143.5 66.72,144.14 U43.15 62.69,144.14 62.05,143.5 v2(58.55,143.5) 56.45,143.5 55.8,144.14 U42.15 51.42,144.14 50.79,143.51 45.52,143.51 44.89,144.14 U41.15 40.5,144.14 v2(40.18,143.82) 39.86,143.5 35.4,143.5 v2(35.35,143.55) 34.76,144.14 U40.15
  INNER1 w0.102: 40.4,136.01 40.4,134.7 v1(40.9,134.2)
  INNER1 w0.2: v2(35.35,143.55) 35.35,139.3 36.4,138.25 38.55,138.25 40.4,136.4 40.4,136.01 ; 59.2,164.05 59.2,163.3 62.7,159.8 62.7,144.22 62,143.52 59.17,143.52 59.15,143.5 v2(58.55,143.5) ; 132.15,145.02 v2(122.62,145.02)
  INNER1 w0.4: 132.15,145.02 161,145.02 arc(165.74,143.06) 167.7,138.32 167.7,127.6 arc(165.74,122.86) 161,120.9 157.65,120.9 arc(149.66,117.59) 146.35,109.6 146.35,75.1 145.8,74.55 145.8,72.6 ; 59.2,207.2 59.2,164.05 ; 19.6,215.6 28.6,215.6 29.64,214.56 56.71,214.56 57.75,215.6 61.1,215.6
  INNER2 w0.4: 61.1,215.6 59.2,213.7 59.2,207.2
  BOTTOM w0.2: J7.20 41.05,144.69 v2(40.18,143.82) ; v2(58.55,143.5) 59.65,144.6 J7.70 ; J7.170 v2(89.65,143.5) ; J7.120 74.65,144.6 75.85,143.4 v2(76.9,143.4)
