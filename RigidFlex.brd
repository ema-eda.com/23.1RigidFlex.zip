# Allegro board RigidFlex.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MEMORY.RD3: length 443.3
  TOP w0.1: U1.T15 39.9,135.2
  TOP w0.102: 39.9,135.2 39.9,136.01
  TOP w0.2: v2(122.95,144.02) 121.8,142.87 U47.17 111.33,142.87 110.71,143.5 105.91,143.5 105.28,142.87 U46.17 101.52,142.87 v2(101.5,142.85) 100.1,142.85 99.46,143.5 95.4,143.5 94.75,142.85 92.8,142.85 U45.17 90.96,142.87 90.94,142.85 89.19,142.85 88.54,143.5 84.5,143.5 83.85,142.85 81.89,142.85 U44.17 81.8,142.8 76.65,142.8 75.95,143.5 73.39,143.5 72.75,142.85 70.97,142.85 U43.17 70.94,142.85 67.36,142.85 66.71,143.5 62.7,143.5 62.05,142.85 60.06,142.85 U42.17 56.33,142.87 55.7,143.5 51.45,143.5 50.85,142.9 49.16,142.9 U41.17 46.13,142.87 46.1,142.9 45.6,142.9 45.57,142.87 45.51,142.87 44.88,143.5 40.71,143.5 40.06,142.85 38.23,142.85 U40.17 38.2,142.86 37.75,142.86 37.55,142.66 37.55,139.1 39.9,136.75 39.9,136.01
  INNER1 w0.2: 57.8,164.05 57.8,163.35 59.75,161.4 59.75,154.45 v2(57.65,152.35) ; 132.15,144.02 v2(122.95,144.02)
  INNER1 w0.4: 61.1,218.14 57.49,218.14 56.45,217.1 29.5,217.1 28.46,218.14 19.6,218.14 ; 57.8,164.05 57.8,207.2 ; 132.15,144.02 161,144.02 arc(165.03,142.35) 166.7,138.32 166.7,127.6 arc(165.03,123.57) 161,121.9 157.65,121.9 arc(148.95,118.3) 145.35,109.6 145.35,75.1 144.55,74.3 144.55,72.6
  INNER2 w0.2: v2(89.85,158.25) 89.7,158.4 88.25,158.4 86.65,160 79.52,160 79.07,160.45 76.9,160.45 v2(76.45,160) 74.45,160 73.14,158.69 72.5,158.69 71.87,159.32 65.83,159.32 65.55,159.6 58.9,159.6 57.2,157.9 57.2,152.8 v2(57.65,152.35) 57.65,151.55 57.25,151.15 55.7,151.15 54.4,149.85 v2(40.35,149.85)
  INNER2 w0.4: 57.8,207.2 57.8,215.88 60.06,218.14 61.1,218.14
  BOTTOM w0.2: J7.121 74.95,158.5 v2(76.45,160) ; v2(101.5,142.85) 101.5,146.47 99.05,148.92 99.05,151.31 99.65,151.92 99.65,157.73 98.28,159.1 90.97,159.1 90.97,159.1 90.6,159.1 89.85,158.35 v2(89.85,158.25) 89.95,158.15 J7.171 ; v2(57.65,152.35) 57.8,152.5 59.35,152.5 59.95,153.1 J7.71 ; J7.21 41.35,150.85 v2(40.35,149.85)
MEMORY.RD4: length 376.5
  TOP w0.102: U1.T14 v1(40.9,135.2)
  TOP w0.2: v2(36.2,144.15) 38.2,144.15 U40.18 38.23,144.12 39.63,144.12 40.28,144.76 44.88,144.76 45.51,144.14 U41.18 49.15,144.12 50.79,144.12 51.43,144.76 55.8,144.76 56.42,144.14 U42.18 60.06,144.12 v2(61.75,144.12) 62.02,144.12 62.66,144.76 66.71,144.76 67.34,144.14 68.99,144.14 69,144.15 70.94,144.15 U43.18 70.97,144.12 72.57,144.12 73.22,144.76 76.28,144.76 v2(76.85,144.2) 76.91,144.14 U44.18 81.89,144.12 83.87,144.12 84.52,144.76 88.54,144.76 89.17,144.14 90.24,144.14 v2(90.25,144.15) 90.26,144.14 U45.18 ; U45.18 92.8,144.12 94.72,144.12 95.37,144.76 99.46,144.76 100.08,144.14 U46.18 105.4,144.14 106.02,144.76 110.73,144.76 111.36,144.14 U47.18 120.65,144.14 v2(122.53,146.02) ; U45.18 92.77,144.15
  INNER1 w0.102: 40.9,136.01 v1(40.9,135.2)
  INNER1 w0.2: 132.15,146.02 v2(122.53,146.02) ; 58.5,164.05 58.5,163.4 60.95,160.95 60.95,144.92 v2(61.75,144.12) ; 40.9,136.01 40.9,136.5 38.75,138.65 36.7,138.65 36.2,139.15 v2(36.2,144.15)
  INNER1 w0.4: 58.5,207.2 58.5,164.05 ; 132.15,146.02 161,146.02 arc(166.44,143.77) 168.7,138.32 168.7,127.6 arc(166.44,122.16) 161,119.9 157.65,119.9 arc(150.37,116.88) 147.35,109.6 147.35,75.1 147.05,74.8 147.05,72.6 ; 19.6,220.68 28.52,220.68 29.56,219.64 56.19,219.64 57.23,220.68 61.1,220.68
  INNER2 w0.4: 58.5,207.2 58.5,215.54 60.06,217.1 61.53,217.1 62.14,217.71 62.14,219.64 61.1,220.68
  BOTTOM w0.1: 41.65,136.01 41.65,135.95 v1(40.9,135.2)
  BOTTOM w0.2: 41.65,136.01 41.6,136.06 41.6,141.9 41.65,141.95 J7.22 ; v2(61.75,144.12) 60.68,144.12 60.25,144.55 J7.72 ; v2(76.85,144.2) 76,144.2 75.25,144.95 J7.122 ; J7.172 v2(90.25,144.15)
MEMORY.RD5: length 449.5
  TOP w0.102: U1.T13 v1(41.9,135.2)
  TOP w0.2: v2(34.85,145.4) 35.75,145.4 35.76,145.41 U40.19 ; 38.2,145.4 U40.19 ; U40.19 38.23,145.39 39.49,145.39 40.13,146.03 44.88,146.03 45.51,145.41 U41.19 49.15,145.39 50.86,145.39 51.5,146.03 55.8,146.03 56.42,145.41 U42.19 60.06,145.39 61.99,145.39 62.63,146.03 66.71,146.03 67.34,145.41 U43.19 70.97,145.39 72.57,145.39 73.22,146.03 77.41,146.03 78.04,145.41 U44.19 81.91,145.45 83.55,145.45 84.13,146.03 88.54,146.03 89.17,145.41 U45.19 92.8,145.39 94.74,145.39 95.38,146.03 99.46,146.03 100.09,145.4 v2(100.75,145.4) 103.69,145.4 U46.19 105.27,145.41 105.51,145.66 105.53,145.66 105.91,146.03 110.71,146.03 111.34,145.41 U47.19 119.75,145.41 v2(122.36,148.02)
  INNER1 w0.1: 41.9,136.01 v1(41.9,135.2)
  INNER1 w0.2: 57.1,161.95 57.1,157.8 v2(57.9,157) ; 57.1,161.95 57.1,164.05 ; 57.1,161.95 55.1,161.95 53.17,160.02 46.55,160.02 46.53,160 v2(44.25,160) ; 41.9,136.01 41.9,136.15 38.95,139.1 37.05,139.1 36.8,139.35 36.8,144.65 36.05,145.4 v2(34.85,145.4) ; 132.15,148.02 v2(122.36,148.02)
  INNER1 w0.4: 57.1,164.05 57.1,207.2 ; 149.5,72.6 149.5,74.95 149.35,75.1 149.35,109.6 arc(151.78,115.47) 157.65,117.9 161,117.9 arc(167.86,120.74) 170.7,127.6 170.7,138.32 arc(167.86,145.18) 161,148.02 132.15,148.02 ; 19.6,223.22 28.38,223.22 29.42,222.18 55.98,222.18 57.02,223.22 61.1,223.22
  INNER2 w0.2: v2(99.05,153.4) 99,153.35 77.45,153.35 v2(76.4,152.3) 75.65,153.05 69.75,153.05 66.45,156.35 59.95,156.35 59.3,157 v2(57.9,157)
  INNER2 w0.4: 57.1,207.2 57.1,219.22 61.1,223.22
  BOTTOM w0.2: J7.23 41.95,155.7 42.6,156.35 42.6,158.35 v2(44.25,160) ; v2(100.75,145.4) 100.75,146.65 98.65,148.75 98.65,151.48 99.05,151.88 v2(99.05,153.4) 99.05,157.77 98.12,158.7 90.8,158.7 90.45,158.35 90.45,156.85 90.55,156.75 J7.173 ; v2(57.9,157) 59.35,157 60.55,155.8 J7.73 ; v2(76.4,152.3) 76.15,152.55 75.7,152.55 75.55,152.7 J7.123
MEMORY.RD6: length 409
  TOP w0.102: U1.R12 v1(42.9,134.2)
  TOP w0.15: 61.92,146.66 62.81,147.32
  TOP w0.2: v2(34.87,146.68) U40.20 ; U40.20 38.19,146.7 ; U40.20 38.23,146.66 39.51,146.66 40.16,147.31 44.88,147.31 45.51,146.68 U41.20 49.15,146.66 50.91,146.66 51.55,147.31 55.35,147.31 55.8,147.75 v2(56.6,147.75) 57.67,146.68 U42.20 60.06,146.66 61.92,146.66 ; v2(121.99,150.02) 118.65,146.68 U47.20 111.37,146.68 110.75,147.31 105.97,147.31 105.34,146.68 U46.20 100.08,146.68 99.46,147.3 97.76,147.3 97.76,147.31 95.44,147.31 94.79,146.66 92.8,146.66 U45.20 90.67,146.68 v2(89.35,148) 88.85,148.5 88.05,148.5 86.85,147.31 84.13,147.31 83.49,146.66 81.89,146.66 U44.20 78.75,146.68 77.33,148.1 v2(77.05,148.1) 76.8,148.1 76,147.31 73.22,147.31 72.57,146.66 70.97,146.66 U43.20 67.34,146.68 66.69,147.32 62.81,147.32
  INNER1 w0.1: v1(42.9,134.2) 42.9,134.6 43.4,135.1 43.4,136.01
  INNER1 w0.2: v2(34.87,146.68) 34.87,153.05 42.42,160.6 53.17,160.6 54.92,162.35 56,162.35 56.4,162.75 56.4,164.05 ; v2(42.2,141.65) 43.4,140.45 43.4,136.01 ; 132.15,150.02 v2(121.99,150.02)
  INNER1 w0.4: 152,72.6 152,74.45 151.35,75.1 151.35,109.6 arc(153.2,114.05) 157.65,115.9 161,115.9 arc(169.27,119.33) 172.7,127.6 172.7,138.32 arc(169.27,146.6) 161,150.02 132.15,150.02 ; 61.1,225.76 57.06,225.76 56.02,224.72 29.38,224.72 28.34,225.76 19.6,225.76 ; 56.4,207.2 56.4,164.05
  INNER2 w0.2: v2(34.87,146.68) 41.42,146.68 42.2,145.9 v2(42.2,141.65)
  INNER2 w0.4: 56.4,207.2 56.4,217.58 55.8,218.18 55.8,222.15 59.41,225.76 61.1,225.76
  BOTTOM w0.2: J7.174 90.85,147.55 90.4,148 v2(89.35,148) ; J7.124 75.85,147.55 76.4,148.1 v2(77.05,148.1) ; v2(42.2,141.65) 42.2,146.1 J7.24 ; v2(56.6,147.75) 57.84,147.75 57.97,147.88 58.93,147.88 59.06,147.75 60.65,147.75 60.85,147.55 J7.74
MEMORY.RD7: length 404.9
  TOP w0.102: U1.T12 v1(42.9,135.2)
  TOP w0.2: v2(35.55,148.1) 35.7,147.95 U40.21 38.23,147.93 39.58,147.93 40.22,148.57 v2(43.53,148.57) 44.88,148.57 45.51,147.95 U41.21 49.15,147.93 50.98,147.93 51.64,148.59 54.1,148.59 54.3,148.8 57.15,148.8 58,147.95 U42.21 60.06,147.93 61.18,147.93 61.84,148.59 61.85,148.6 62.35,148.6 62.35,148.59 65.15,148.59 65.9,149.35 v2(66.05,149.35) 67.35,149.35 68.9,147.8 70.81,147.8 U43.21 70.97,147.93 72.57,147.93 73.24,148.59 75.94,148.59 76.6,149.25 77.6,149.25 v2(78.25,148.6) 79,148.6 79.65,147.95 U44.21 81.89,147.93 83.49,147.93 84.15,148.59 86.84,148.59 87.55,149.3 89.52,149.3 90.87,147.95 U45.21 ; U45.21 v2(94.4,147.95) 95.03,148.57 97.91,148.57 98.23,148.9 99.35,148.9 100.3,147.95 U46.21 105.28,147.95 105.91,148.57 110.73,148.57 111.35,147.95 U47.21 114.66,147.9 118.55,147.9 v2(121.67,151.02) ; U45.21 92.8,147.93
  INNER1 w0.102: 42.9,135.85 v1(42.9,135.2)
  INNER1 w0.2: 42.9,135.85 39.2,139.55 37.4,139.55 37.2,139.75 37.2,146.45 v2(35.55,148.1) ; 132.15,151.02 v2(121.67,151.02) ; v2(55.7,163.15) 55.7,164.05
  INNER1 w0.4: 132.15,151.02 161,151.02 arc(169.98,147.3) 173.7,138.32 173.7,127.6 arc(169.98,118.62) 161,114.9 157.65,114.9 arc(153.94,113.36) 152.4,109.65 152.4,75.1 153.25,74.25 153.25,72.6 ; 19.6,228.3 28.2,228.3 29.24,227.26 55.86,227.26 56.9,228.3 61.1,228.3 ; 55.7,164.05 55.7,207.2
  INNER2 w0.4: 61.1,228.3 55.2,222.4 55.2,217.93 55.7,217.43 55.7,207.2
  BOTTOM w0.2: v2(78.25,148.6) 78.25,151.8 77.15,152.9 76.4,152.9 76.15,153.15 J7.125 ; v2(66.05,149.35) 64.5,150.9 61.7,150.9 61.15,151.45 J7.75 61.15,157.1 60.85,157.4 60.85,158.6 61.25,159 61.25,162.77 60.87,163.15 v2(55.7,163.15) ; v2(43.53,148.57) 43.53,151.87 42.55,152.85 J7.25 ; J7.175 91.15,153.25 91.45,152.95 92.1,152.95 92.5,152.55 92.5,151.85 93.6,150.75 93.6,148.75 v2(94.4,147.95)
MRD/: length 17.3
  TOP w0.2: J6.E4 4.87,83.25 4.02,82.4 4.02,81.7 4.51,81.2 5.25,81.2 6.77,79.68 9.5,79.68 10.51,78.66 11.61,78.66 11.94,78.99 U7.8
MWR/: length 21.4
  TOP w0.2: U7.9 13.72,77.72 13.14,77.14 12.26,77.14 11.58,77.82 10.51,77.82 10.29,77.6 8.28,77.6 5.08,80.8 4.35,80.8 3.62,81.53 3.62,82.57 4.02,82.97 4.02,86.27 4.87,87.12 J6.E5
N00036_USER_DESIGN_OUTPUTS0_DAAMP0: length 39.4
  TOP w0.2: 93.45,58.97 93.75,59.27 93.75,60.97 94,61.22 95.44,61.22 95.45,61.21 v2(97.13,61.21) ; 93.45,58.97 U32.8 90.88,58.97 90.79,59.06 88.16,59.06 87.7,58.6 87.7,50.4 89.05,49.05 96.25,49.05 96.68,49.48 L8.2 98.38,51 R54.1 ; 93.45,58.97 93.45,55.75 92.86,55.16 U32.5
  BOTTOM w0.2: v2(97.13,61.21) 97.12,61.2 R53.1
N00036_USER_DESIGN_OUTPUTS0_DAAMP1: length 33.7
  TOP w0.2: v2(97.13,76.69) 95.45,76.69 95.44,76.7 94,76.7 93.75,76.45 93.75,74.75 93.45,74.45 U35.8 90.3,74.45 89.75,73.9 89.75,70.64 ; 89.75,70.64 89.75,69.61 89.75,69.6 89.75,65.11 90.75,64.09 96.04,64.09 96.7,64.75 96.7,66.45 L10.2 98.38,66.48 R56.1 ; 89.75,70.64 U35.5
  BOTTOM w0.2: R55.1 95.54,76.69 v2(97.13,76.69)
N00038_USER_DESIGN_OUTPUTS0_DAAMP0: length 5.5
  TOP w0.2: 94.39,54.2 94.08,53.89 93.28,53.89 93.25,53.92 92.16,53.92 U32.4 92.1,53.92 91.02,53.92 90.99,53.89 v2(90.64,53.89)
  BOTTOM w0.2: v2(90.64,53.89) 91.83,53.89 C198.1
N00038_USER_DESIGN_OUTPUTS0_DAAMP1: length 6.1
  TOP w0.2: v2(90.35,69.35) 92.11,69.35 U35.4 94.08,69.37 L9.2
  BOTTOM w0.2: 92.13,69.68 90.68,69.68 v2(90.35,69.35)
N00044_USER_DESIGN_OUTPUTS0_DAAMP0: length 6.6
  TOP w0.2: U33.1 100.46,57.37 101.95,57.37 102.3,57.72 v2(102.3,59.87)
  BOTTOM w0.2: U34.2 102.89,60.46 v2(102.3,59.87)
N00044_USER_DESIGN_OUTPUTS0_DAAMP1: length 6.6
  TOP w0.2: U36.1 100.46,72.85 101.95,72.85 102.3,73.2 v2(102.3,75.35)
  BOTTOM w0.2: U37.2 102.89,75.94 v2(102.3,75.35)
N00046_USER_DESIGN_OUTPUTS0_DAAMP0: length 9.2
  TOP w0.2: 95.45,57.4 97.05,57.4 100.48,53.97 R54.2
N00046_USER_DESIGN_OUTPUTS0_DAAMP1: length 9.2
  TOP w0.2: 95.45,72.88 96.93,72.88 100.5,69.3 100.5,66.69 R56.2
N00048_USER_DESIGN_OUTPUTS0_DAAMP0: length 5.2
  TOP w0.2: v2(97.45,59.3) 97.87,59.3 98.5,58.67 U33.2
  BOTTOM w0.2: R53.2 95.61,59.27 97.22,59.27 97.25,59.3 v2(97.45,59.3)
N00048_USER_DESIGN_OUTPUTS0_DAAMP1: length 5.1
  TOP w0.2: v2(97.95,74.7) 98.5,74.15 U36.2
  BOTTOM w0.2: v2(97.95,74.7) 97.93,74.68 R55.2
N00060_USER_DESIGN_OUTPUTS0_DAAMP0: length 15.4
  TOP w0.2: U32.6 90.77,56.43 v2(90.75,56.45)
  BOTTOM w0.2: 103.79,58.66 101.57,56.43 90.77,56.43 v2(90.75,56.45)
N00060_USER_DESIGN_OUTPUTS0_DAAMP1: length 12.6
  TOP w0.2: U35.6 v2(93.76,71.91)
  BOTTOM w0.2: 103.79,74.14 101.57,71.91 v2(93.76,71.91)
Net_650: length 3.7
  TOP w0.2: 74.77,161.92 76.87,161.92 v2(77.4,162.45)
  INNER1 w0.2: v2(77.4,162.45) 78.25,162.45
PGOOD: length 2.6
  TOP w0.2: U51.9 74.91,83.3 v2(75.15,83.54)
  BOTTOM w0.2: v2(75.15,83.54) 75.15,83.05 74.66,82.56 R2012.2
Q1E: length 3.1
  TOP w0.5: Q9.2 111.77,128.28 R52.2
Q2E: length 7.2
  TOP w0.5: R45.1 96.5,137.46 C68.2 97.81,137.4 R47.2 98.58,136.56 Q8.2
R/W: length 177.4
  TOP w0.1: U1.D3 v1(51.92,123.18)
  INNER1 w0.1: 38.32,129.65 38.82,129.15 41.25,129.15 43.2,127.2 46.15,127.2 46.85,126.5 46.85,124.45 47.6,123.7 51.4,123.7 v1(51.92,123.18)
  INNER1 w0.2: 38.32,129.65 33.6,129.65 28.1,135.15 28.1,149.48 31.45,152.83 31.45,157.63 35.62,161.8 52.67,161.8 53.6,162.73 53.6,164.05
  INNER1 w0.4: 53.6,207.2 53.6,164.05 ; 93.1,218.14 84.01,218.14 82.97,219.18 57.23,219.18 56.19,218.14 51.6,218.14
  INNER2 w0.4: 51.6,218.14 53.6,216.14 53.6,207.2
RDY/: length 23.3
  TOP w0.2: v2(21.55,88.5) 23.44,86.61 U7.19
  INNER2 w0.2: J6.E6 9.42,89.67 10.4,90.65 11.55,90.65 13.72,88.48 21.53,88.48 v2(21.55,88.5)
RESET: length 73.4
  TOP w0.1: 47.66,118.74 46.9,119.5 46.9,126.85 46.6,127.15 44.45,127.15 43.9,127.7 43.9,130.2 U1.M12
  TOP w0.102: U2.T11 v1(62.25,88.15)
  TOP w0.2: v2(62.45,76.95) 63.6,76.95 U49.2 ; U50.11 61.7,83.3 v2(61.5,83.1) ; v2(48.5,117.9) 47.66,118.74
  INNER1 w0.1: 53.73,104.67 53.75,104.65 53.75,102.45 54.65,101.55 54.65,101 55,100.65 55.9,100.65 57.75,98.8 57.75,88.75 58.35,88.15 v1(62.25,88.15)
  INNER1 w0.2: 53.73,104.67 52.9,105.5 50.7,105.5 49.7,106.5 49.7,112.7 48.92,113.47 48.92,117.48 v2(48.5,117.9)
  BOTTOM w0.1: v1(62.25,88.15) 62.9,87.5
  BOTTOM w0.2: 62.9,87.5 63.15,87.25 63.15,86.78 63.15,86.78 63.15,86.12 63.15,86.12 63.15,84.4 61.85,83.1 v2(61.5,83.1) 61.42,83.02 61.42,77.98 v2(62.45,76.95) 62.95,76.95 63.52,77.52 R2008.2
RESET/: length 16.9
  TOP w0.2: J6.E1 4.9,76.94 4.9,73.05 6.25,71.7 13.55,71.7 15.15,70.1 U48.3
RS: length 181.6
  TOP w0.1: U1.D1 v1(53.92,122.22)
  INNER1 w0.1: 38.32,130.22 38.78,129.75 42.55,129.75 44.75,127.55 46.35,127.55 47.1,126.8 47.1,125.25 47.65,124.7 52.05,124.7 53.45,123.3 53.45,122.69 v1(53.92,122.22)
  INNER1 w0.2: 38.32,130.22 34.83,130.22 28.5,136.55 28.5,149.32 31.85,152.67 31.85,157.47 35.78,161.4 52.83,161.4 54.3,162.87 54.3,164.05
  INNER1 w0.4: 51.6,220.68 55.88,220.68 56.92,221.72 82.68,221.72 83.72,220.68 93.1,220.68 ; 54.3,207.2 54.3,164.05
  INNER2 w0.4: 54.3,207.2 54.3,217.98 51.6,220.68
SEL: length 0
  TOP w0.2: 16.66,62.5 U48.9
STDA_SSRX+: length 71.4
  TOP w0.102: U2.A8 v1(58.25,104.15)
  BOTTOM w0.102: 59.59,104.83 59.57,104.81 59.57,104.79 59.56,104.79 58.91,104.15 v1(58.25,104.15)
  BOTTOM w0.127: 59.59,104.83 61.11,106.35 82.77,106.35 84.45,108.03 102.78,108.03 105.2,110.45 105.2,118.43 105.62,118.85 113.28,118.85 113.55,118.58 113.55,118.29 C2003.1 114.3,117.54 114.3,117.06 116.21,117.06 116.3,117.15 116.3,117.75 R2002.2
STDA_SSRX-: length 73
  TOP w0.102: U2.B8 v1(58.25,103.15)
  BOTTOM w0.102: 59.77,104.65 59.75,104.63 59.72,104.63 59.01,103.92 58.57,103.92 58.25,103.6 v1(58.25,103.15)
  BOTTOM w0.127: C2002.1 114.2,116.22 114.2,116.8 ; 114.2,116.8 114.19,116.8 114,116.99 113.5,116.99 113.3,117.19 113.3,118.47 113.17,118.6 105.72,118.6 105.45,118.33 105.45,110.34 102.89,107.78 84.55,107.78 82.88,106.1 61.22,106.1 59.77,104.65 ; 114.2,116.8 116.2,116.8 116.3,116.7 116.3,116.11 R2003.2
STDA_SSTX+: length 68.5
  TOP w0.102: U2.E7 v1(57.25,100.15)
  BOTTOM w0.1: 60.47,104.49 60.45,104.47 60.44,104.47 58.73,102.76 58.73,102.01 58.73,102.01
  BOTTOM w0.102: v1(57.25,100.15) 57.7,100.15 58.09,99.76 58.41,99.76 58.63,99.98 58.63,100.31 58.41,100.53 58.25,100.53 57.93,100.85 57.93,101.21 58.73,102.01
  BOTTOM w0.127: 60.47,104.49 61.5,105.52 83.12,105.52 84.8,107.2 113.21,107.2 113.8,107.79 113.8,108.79 113.6,109 113.6,109.12 113.97,109.5 C2004.1 114.25,109.67 114.25,110.2 116.2,110.2 116.3,110.1 116.3,109.51 R2005.2
STDA_SSTX-: length 67.9
  TOP w0.102: U2.E8 v1(58.25,100.15)
  BOTTOM w0.1: 60.29,104.67 60.28,104.66 60.28,104.64 60.23,104.59 60.23,104.59 58.5,102.85 58.5,102.1
  BOTTOM w0.102: v1(58.25,100.15) 57.7,100.7 57.7,101.31 58.5,102.1
  BOTTOM w0.127: R2004.2 116.3,111.15 116.3,110.55 116.2,110.45 114.1,110.45 ; 114.1,110.45 114.1,111.15 C2005.1 ; 114.1,110.45 113.91,110.27 113.5,110.27 113.34,110.11 113.34,108.89 113.55,108.69 113.55,107.9 113.1,107.45 84.69,107.45 83.01,105.77 61.4,105.77 60.29,104.67
TCLK: length 80.2
  TOP w0.102: U2.C14 v1(65.25,102.15) ; U1.C14 v1(40.9,121.2)
  INNER2 w0.1: 39.68,118.74 39.68,118.77 39.5,118.95 39.5,119.35 39.75,119.6 40.25,119.6 40.9,120.25 v1(40.9,121.2) ; v1(65.25,102.15) 64.87,102.53 64.87,104.67
  INNER2 w0.2: 64.87,104.67 64.87,109.28 62.9,111.25 53.93,111.25 51.55,113.63 51.55,114.45 50.2,115.8 41.18,115.8 39.68,117.3 39.68,118.74
  BOTTOM w0.1: 61.3,87.5 60.67,88.13
  BOTTOM w0.102: v1(65.25,102.15) 64.87,101.77 64.87,93.62 64.23,92.98 62.15,92.98 61.65,92.48 61.65,91.95 61.45,91.75 60.9,91.75 60.9,91.71 60.67,91.48 60.67,88.13
  BOTTOM w0.2: 61.3,87.5 62.35,86.45 62.35,84.85 61.7,84.2 60.68,84.2 59.74,83.25 57.48,83.25 57.05,82.83 49.33,82.83 47.76,81.26 P1.3
TDO: length 44.7
  TOP w0.102: U1.E14 v1(40.9,123.2) ; U2.C12 v1(63.25,102.15)
  INNER2 w0.1: v1(63.25,102.15) 63.63,102.53 63.63,104.67 ; 39.28,118.74 39.28,119.39 39.67,119.78 40.17,119.78 40.5,120.11 40.5,121.4 40.75,121.65 41.05,121.65 41.28,121.88 41.28,122.36 40.9,122.74 v1(40.9,123.2)
  INNER2 w0.2: 39.28,118.74 39.28,117.13 41.01,115.4 50.03,115.4 51.15,114.28 51.15,113.47 53.77,110.85 62.73,110.85 63.63,109.95 63.63,104.67
TMS: length 89.5
  TOP w0.102: U2.A15 v1(66.25,104.15) ; U1.A15 v1(39.9,119.2)
  INNER1 w0.102: 39.9,118.74 v1(39.9,119.2)
  INNER1 w0.2: 39.9,118.74 39.9,115.35 39.26,114.71 35.46,114.71 29.05,108.3 29.05,84.15 29.75,83.45 35.35,83.45 37.6,81.2 P1.11
  INNER2 w0.1: 66.25,104.67 v1(66.25,104.15) ; v1(39.9,119.2) 40.1,119 40.1,118.74
  INNER2 w0.2: 66.25,104.67 66.25,108.5 63.1,111.65 54.1,111.65 51.95,113.8 51.95,114.65 50.4,116.2 41.5,116.2 40.1,117.6 40.1,118.74
V+12: length 94.7
  TOP w0.5: v2(94.5,140.55) 94.5,139.62 ; 94.5,139.62 R45.2 ; 94.5,139.62 92.32,139.62 91.82,139.12 D5.1 R19.2 86.51,139.12 C39.2 ; U29.L5 88.42,99.18 88.4,99.2 ; U5.1 v2(38.67,64.22) ; U36.4 v2(98.73,76.69) ; v2(31.15,69.75) 30.62,69.22 U3.8 ; U30.L5 97.77,99.18 97.75,99.2 ; 107.2,99.2 107.22,99.18 U31.L5 ; U33.4 v2(98.73,61.21)
  INNER2 w0.5: 12,77.37 J6.A2 ; J6.A2 13.23,77.37 ; J6.A2 13.23,78.6 ; J6.A2 12,78.6 ; 108.15,101.7 108.15,121.25 96.3,133.1 96.3,138.75 v2(94.5,140.55) ; 107.83,74.14 U37.7 ; U37.7 109.66,74.92 ; U37.7 109.66,73.35 ; J6.D1 7.23,76.57 ; J6.D1 7.23,75.34 ; J6.D1 6,76.57 ; J6.D1 6,75.34 ; J6.A1 13.23,76.57 ; J6.A1 13.23,75.34 ; J6.A1 12,76.57 ; J6.A1 12,75.34 ; 6,77.37 J6.D2 ; J6.D2 6,78.6 ; J6.D2 7.23,78.6 ; J6.D2 7.23,77.37 ; 107.83,58.66 U34.7 ; U34.7 109.66,59.44 ; U34.7 109.66,57.87
  BOTTOM w0.5: v2(98.73,76.69) 99.12,77.08 C202.1 ; C31.2 C32.2 32.18,69.75 v2(31.15,69.75) 29.67,69.75 C33.2 ; v2(98.73,61.21) 99.12,61.6 C199.1
  vias: v2(87.3,95.5) v2(87.3,94.7) v2(88.1,95.5) v2(88.1,94.7) v2(94.9,97.2) v2(94.9,96.4) v2(95.7,97.2) v2(95.7,96.4) v2(103.5,97.4) v2(103.5,96.6) v2(104.3,97.4) v2(104.3,96.6)
VCLKC: length 3.6
  TOP w0.2: U39.11 v2(76.91,65.56)
  BOTTOM w0.2: R26.2 78.59,65.56 v2(76.91,65.56)
VDX0: length 256.2
  TOP w0.2: v2(62.87,51.35) U38.9 69.1,51.35 70.85,51.35 73.6,54.1 73.6,63.06 71.7,64.96 68.09,64.96 67.55,65.5 67.55,66.45 67.93,66.83 U39.9 73.58,66.83 77.25,70.5 77.25,77.55 78.65,78.95 92.95,78.95 97.7,83.7 100.1,83.7 U22.9 100.16,83.65 101.6,83.65 v2(101.8,83.85) ; U48.11 v2(27.42,61.21)
  INNER1 w0.2: 62.35,48.5 62.35,50.84 v2(62.87,51.35) 60.42,53.8 29.8,53.8 27.42,56.18 v2(27.42,61.21)
  INNER1 w0.3: 62.35,48.5 62.35,9 arc(64.72,3.27) 70.45,0.9 113.55,0.9 arc(119.28,3.27) 121.65,9 121.65,22 123.9,24.25 123.9,25.61
  BOTTOM w0.2: R8.2 96.6,80.3 100.15,83.85 v2(101.8,83.85) 103.07,85.12 RN2.5
VDX1: length 254.7
  TOP w0.2: v2(62.87,52.62) U38.8 69.12,52.6 70.95,52.6 73.2,54.85 73.2,62.9 71.53,64.56 67.92,64.56 67.15,65.33 67.15,67.25 68,68.1 U39.8 73.35,68.1 76.85,71.6 76.85,77.72 78.48,79.35 92.15,79.35 97.75,84.95 100.12,84.95 U22.8 100.18,84.95 v2(101.95,84.95) ; U48.12 v2(27.42,62.48)
  INNER1 w0.2: 62.95,48.5 62.95,50.5 63.46,51.02 63.46,52.02 v2(62.87,52.62) 61.29,54.2 30,54.2 28.1,56.1 28.1,61.8 v2(27.42,62.48)
  INNER1 w0.3: 62.95,48.5 62.95,9 arc(65.15,3.7) 70.45,1.5 113.55,1.5 arc(118.85,3.7) 121.05,9 121.05,22.65 122.65,24.25 122.65,25.61
  BOTTOM w0.2: RN2.6 102.52,85.52 v2(101.95,84.95) 99.2,84.95 96.6,82.35 R6.2
VDX2: length 253
  TOP w0.2: U48.13 v2(27.42,63.75) ; v2(62.87,53.89) U38.7 69.1,53.9 70.85,53.9 72.8,55.85 72.8,62.73 71.37,64.16 67.76,64.16 66.75,65.17 66.75,67.7 68.42,69.37 U39.7 69.12,69.35 72.95,69.35 76.45,72.85 76.45,77.88 78.32,79.75 91.2,79.75 97.65,86.19 U22.7 100.16,86.2 v2(102.05,86.2)
  INNER1 w0.2: 63.55,48.5 63.55,50.53 63.87,50.85 63.87,52.89 v2(62.87,53.89) 62.16,54.6 30.17,54.6 28.5,56.27 28.5,62.67 v2(27.42,63.75)
  INNER1 w0.3: 121.4,25.61 121.4,24.25 120.45,23.3 120.45,9 arc(118.43,4.12) 113.55,2.1 70.45,2.1 arc(65.57,4.12) 63.55,9 63.55,48.5
  BOTTOM w0.2: RN2.7 102.33,85.92 v2(102.05,86.2) 98.4,86.2 96.6,84.4 R4.2
VDX3: length 252.6
  TOP w0.2: U48.14 v2(27.42,65.02) ; v2(102.25,87.1) 101.9,87.45 100.16,87.45 U22.6 100.12,87.5 97.8,87.5 90.45,80.15 78.15,80.15 76.05,78.05 76.05,73.55 73.14,70.64 U39.6 69,70.55 67.95,70.55 66.35,68.95 66.35,65 67.59,63.76 71.2,63.76 72.4,62.56 72.4,56.96 70.6,55.16 U38.6 v2(62.87,55.16)
  INNER1 w0.2: 64.15,48.5 64.15,50.57 64.27,50.68 64.27,53.76 v2(62.87,55.16) 62.27,55.16 62.1,55 30.34,55 28.9,56.44 28.9,63.54 v2(27.42,65.02)
  INNER1 w0.3: 64.15,48.5 64.15,9 arc(66,4.55) 70.45,2.7 113.55,2.7 arc(118,4.55) 119.85,9 119.85,23.95 120.15,24.25 120.15,25.61
  BOTTOM w0.2: RN2.8 103.03,86.32 v2(102.25,87.1) 97.2,87.1 96.6,86.5 R2.2
VDX4: length 252.1
  TOP w0.2: U48.15 v2(27.42,66.29) ; v2(62.87,56.43) U38.5 70.48,56.43 72,57.95 72,62.4 71.04,63.36 67.42,63.36 65.95,64.84 65.95,70.15 67.71,71.91 U39.5 73.31,71.91 75.65,74.25 75.65,78.21 77.99,80.55 89.95,80.55 98.15,88.75 100.13,88.75 U22.5 100.19,88.7 v2(101.5,88.7)
  INNER1 w0.2: 64.75,48.5 64.75,54.55 v2(62.87,56.43) 61.83,55.4 30.5,55.4 29.3,56.6 29.3,64.41 v2(27.42,66.29)
  INNER1 w0.3: 64.75,48.5 64.75,9 arc(66.42,4.97) 70.45,3.3 113.55,3.3 arc(117.58,4.97) 119.25,9 119.25,23.95 118.95,24.25 118.95,25.61
  BOTTOM w0.2: RN3.5 103,90.2 v2(101.5,88.7) 101.2,88.4 R7.2
VDX5: length 252.7
  TOP w0.2: v2(62.87,57.7) U38.4 70.4,57.7 71.6,58.9 71.6,62.23 70.87,62.96 67.26,62.96 65.55,64.67 65.55,71.4 67.35,73.2 69.08,73.2 U39.4 69.18,73.1 73.25,73.1 75.25,75.1 75.25,78.38 77.82,80.95 89.75,80.95 98.81,90 U22.4 100.16,90 v2(101.5,90) ; U48.16 v2(27.42,67.56)
  INNER1 w0.2: 65.35,48.5 65.35,55.22 v2(62.87,57.7) 60.96,55.8 30.67,55.8 29.7,56.77 29.7,65.28 v2(27.42,67.56)
  INNER1 w0.3: 117.7,25.61 117.7,24.25 118.65,23.3 118.65,9 arc(117.16,5.39) 113.55,3.9 70.45,3.9 arc(66.84,5.39) 65.35,9 65.35,48.5
  BOTTOM w0.2: RN3.6 102.1,90.6 v2(101.5,90) 101,90.5 R5.2
VDX6: length 253.8
  TOP w0.2: v2(62.87,58.97) U38.3 70.25,58.97 71.2,59.92 71.2,62.07 70.7,62.56 67.09,62.56 65.15,64.5 65.15,72.8 66.8,74.45 U39.3 73.4,74.45 74.85,75.9 74.85,78.55 77.65,81.35 88.35,81.35 98.3,91.3 100.12,91.3 100.15,91.28 100.18,91.3 v2(101.5,91.3) ; U48.17 v2(27.42,68.83)
  INNER1 w0.2: v2(27.42,68.83) 30.1,66.15 30.1,56.93 30.83,56.2 60.09,56.2 v2(62.87,58.97) 65.95,55.89 65.95,48.5
  INNER1 w0.3: 116.45,25.61 116.45,24.25 118.05,22.65 118.05,9 arc(116.73,5.82) 113.55,4.5 70.45,4.5 arc(67.27,5.82) 65.95,9 65.95,48.5
  BOTTOM w0.2: R3.2 96.6,92.4 97.7,91.3 v2(101.5,91.3) 101.8,91 RN3.7
VDX7: length 255.2
  TOP w0.2: v2(101.45,92.55) 100.16,92.55 U22.2 98.98,92.55 88.18,81.75 77.49,81.75 74.45,78.71 74.45,76.55 73.62,75.72 U39.2 69.07,75.75 66.9,75.75 64.75,73.6 64.75,64.34 66.93,62.16 70.54,62.16 70.8,61.9 70.8,60.85 70.19,60.24 U38.2 v2(62.87,60.24) ; U48.18 v2(27.42,70.1)
  INNER1 w0.2: v2(27.42,70.1) 30.5,67.02 30.5,57.1 31,56.6 59.22,56.6 v2(62.87,60.24) 66.55,56.56 66.55,48.5
  INNER1 w0.3: 66.55,48.5 66.55,9 arc(67.69,6.24) 70.45,5.1 113.55,5.1 arc(116.31,6.24) 117.45,9 117.45,22 115.2,24.25 115.2,25.61
  BOTTOM w0.2: R1.2 96.6,94.5 98.55,92.55 v2(101.45,92.55) 102.6,91.4 RN3.8
VTTREF: length 2.5
  TOP w0.2: U51.6 74.75,81.8 v2(75.15,81.4)
  BOTTOM w0.2: v2(75.15,81.4) 76.44,81.4 C2016.1
WAIT/: length 17.8
  TOP w0.2: J6.E2 5.72,78.66 5.72,74.13 7.05,72.8 13.7,72.8 15.13,71.37 U48.2
N00286: length 10.2
  TOP w0.5: 106.68,126.48 106.68,126.72 L5.2 103.54,126.62 C35.1 100.98,126.73 L6.1 ; 106.68,126.48 C34.1 ; 106.68,126.48 C38.1
N00395: length 6.4
  TOP w0.5: C35.2 99.97,124.82 L6.2 97.77,125.73 R17.1 97.52,123.79 C37.2
N00671: length 2
  BOTTOM w0.2: R1.1 C3.1
N00689: length 2
  BOTTOM w0.2: C5.1 R3.1
N00703: length 2
  BOTTOM w0.2: R5.1 C7.1
N00717: length 2
  BOTTOM w0.2: C9.1 R7.1
N00827: length 2
  BOTTOM w0.2: R2.1 C4.1
N00831: length 2
  BOTTOM w0.2: C6.1 R4.1
N00835: length 2
  BOTTOM w0.2: R6.1 C8.1
N00837: length 2
  BOTTOM w0.2: C10.1 R8.1
N04966: length 18.5
  TOP w0.2: v2(98.1,69.8) 96.8,69.8 L9.1 ; v2(98.1,54.2) 98.1,54.2 L7.1
  INNER1 w0.2: v2(98.1,69.8) v2(98.1,54.2)
N44457: length 25.7
  TOP w0.102: U1.K6 v1(49.9,129.2)
  TOP w0.2: v2(61,117) 61.65,116.35 62.89,116.35
  INNER2 w0.1: 55.59,129.4 55.54,129.4 55.36,129.58 50.28,129.58 v1(49.9,129.2)
  INNER2 w0.2: 55.59,129.4 57.93,129.4 61.85,125.48 61.85,117.55 61.3,117 v2(61,117)
N44464: length 26.1
  TOP w0.1: U1.K3 52.8,129.1 55.23,129.1 55.59,128.75
  TOP w0.2: 68.69,116.35 66.75,116.35 65.75,117.35 65.75,118.85 65,119.6 62.89,119.6 U10.3 61.6,119.6 61.25,119.95 61.25,120.7 60.5,121.45 57.75,121.45 56.85,122.35 56.85,127.48 55.59,128.75
N44478: length 15
  TOP w0.102: U1.E2 v1(53.9,123.2)
  TOP w0.2: v2(61.05,117.85) 61.3,117.85 61.84,117.31 61.84,117.3 62.14,117 U10.7
  INNER2 w0.1: 55.59,123.2 v1(53.9,123.2)
  INNER2 w0.2: 55.59,123.2 60.4,123.2 61.05,122.55 v2(61.05,117.85)
N44485: length 25.5
  TOP w0.102: U1.L4 v1(51.9,130.2)
  TOP w0.2: 62.89,115.05 61.8,115.05 v2(61.1,115.75)
  INNER2 w0.1: 55.59,129.8 52.3,129.8 v1(51.9,130.2)
  INNER2 w0.2: 55.59,129.8 58.1,129.8 62.35,125.55 62.35,117 v2(61.1,115.75)
N44490: length 21.4
  TOP w0.1: U1.L5 50.85,130.15 50.85,130.85 51.15,131.15 52.6,131.15 52.9,130.85 52.9,129.65 53.22,129.33 55.57,129.33 55.59,129.31
  TOP w0.2: U10.1 61.65,120.9 60.7,121.85 57.95,121.85 57.25,122.55 57.25,127.65 55.59,129.31
N45317: length 26.9
  TOP w0.102: U2.M11 v1(62.25,92.15)
  TOP w0.2: U11.1 80.62,97.05 v2(81.95,97.05)
  BOTTOM w0.102: 67.94,90.91 67.75,90.91 67.6,90.77 63.43,90.77 62.25,91.95 v1(62.25,92.15)
  BOTTOM w0.2: v2(81.95,97.05) 81.95,93.95 78.92,90.91 67.94,90.91
N61996: length 1.7
  TOP w0.5: C71.1 103.49,128.51 R50.2
N62056: length 7.3
  TOP w0.5: Q8.1 101.53,135.08 100.9,134.45 98.88,134.45 R51.1 97.54,133.61 R46.1
N62230: length 7.8
  TOP w0.5: Q9.1 107.17,130.18 C71.2 R49.1 102.47,132.34 R48.1
N62316: length 3.2
  TOP w0.5: Q8.3 100.6,133.21 100.6,131.82 ; 100.6,131.82 R48.2 ; 100.6,131.82 100.21,131.82 C72.2
N62436: length 5
  TOP w0.5: R46.2 95.5,135.1 94.1,135.1 92.84,136.36 D5.3
N62564: length 13.7
  TOP w0.5: R47.1 101.69,138.05 C69.1 107.33,138.05 Q9.3 109.96,136.39 C70.1
N68133: length 7.7
  TOP w0.5: R23.2 92.69,127.3 C42.2 ; R23.2 R21.1 ; R23.2 92.69,131.58 Q3.1
N70364: length 6.4
  TOP w0.5: R24.2 88.43,131 C43.2 Q3.2
N80550: length 2.3
  TOP w0.5: C40.2 88.39,135.63 R19.1
N81780: length 1.9
  TOP w0.5: R49.2 C69.2
N84247: length 41.7
  TOP w0.2: U8.9 18.04,119.1 17.16,119.1 17.06,119.2 16.56,119.2 16.46,119.1 v2(16.15,119.1) 16.15,118.4 16.96,117.59 U8.12 ; v2(16.75,128.8) 16.75,128.89 17.22,129.36 U6.22 ; U9.20 17.04,96.58 16.94,96.68 16.44,96.68 16.33,96.58 v2(15.87,96.58)
  BOTTOM w0.2: v2(16.75,128.8) 16.15,128.2 v2(16.15,119.1) 16.15,106.15 15.3,105.3 15.3,99.86 15.29,99.85 15.29,99.35 15.3,99.34 15.3,97.15 v2(15.87,96.58)
N103899: length 46.5
  TOP w0.2: U8.8 v2(19.29,119.59) 19.29,118.24 19.15,118.1 18.05,118.1 U8.11 ; U9.23 18.75,95.08 18.95,95.28 18.95,96.3 19.2,96.55 v2(19.2,97.1) 17.94,97.1 U9.19 ; U6.23 18.05,128.85 19.05,128.85 19.29,129.09 v2(19.3,129.09) 19.3,130.65 19.09,130.86 U6.19
  INNER2 w0.2: v2(19.3,129.09) 18.79,128.59 18.79,120.09 v2(19.29,119.59)
  BOTTOM w0.2: v2(19.2,97.1) 18.1,98.2 18.1,105.25 20,107.16 20,118.89 19.31,119.59 v2(19.29,119.59)
N108857: length 2.7
  TOP w0.2: U4.21 v2(79.54,110.56)
  BOTTOM w0.5: R12.2 78.25,110.56 v2(79.54,110.56)
N108997: length 5.3
  TOP w0.2: U4.12 v2(72.34,107.96)
  BOTTOM w0.2: R14.2 76.16,107.96 v2(72.34,107.96)
N111502: length 5.1
  TOP w0.5: U3.1 36.38,69.22 36.5,69.34 ; C11.1 37.11,67.39 36.5,68 36.5,69.34 ; 36.5,69.34 C12.2
N111881: length 28.6
  TOP w0.5: C13.2 40.61,67.39 ; 40.61,67.39 C11.2 39.34,69.09 R11.1 39.41,71.05 C14.2 39.36,71.4 R9.2 ; 40.61,67.39 40.61,66.59 40.89,66.31 40.89,66.29 41.2,65.98 41.2,60.15 42.5,58.85 49,58.85 49.5,58.35 49.5,57.25 51.05,55.7 R10.2
N113142: length 5
  TOP w0.5: L4.1 45.05,72.3 44.21,73.14 C15.2 41.46,73.14 R9.1
N114006: length 10.3
  TOP w0.5: R10.1 52.53,54.17 C18.1 52.88,51.75 R13.2 55,51.78 55,53 55.75,53.75 Q1.1 58.75,53.75 C20.1
N118214: length 28.8
  TOP w0.5: v2(40.8,49.55) 41.8,49.55 C19.1 ; Q1.3 54.95,55.95 54.1,56.8 51.39,56.8 50.25,57.94 50.25,58.65 48.58,60.32 L3.3
  BOTTOM w0.5: L3.3 44.63,60.3 42.65,60.3 40.8,58.45 v2(40.8,49.55)
N118917: length 6.7
  TOP w0.5: R11.2 41.35,69.2 C16.2 43.85,69.2 44.65,68.4 L3.1
N120412: length 4.8
  TOP w0.5: C17.1 45.24,63.45 L3.2
N121910: length 8.9
  TOP w0.5: Q1.2 58.75,55.65 C20.2 59.2,55.5 59.95,54.75 59.95,52.35 59.4,51.8 R15.2 C21.2
N123723: length 10.2
  TOP w0.5: R16.2 Q2.3 50.55,61.1 C17.2
N124926: length 41.6
  TOP w0.5: XTAL1.3 43.88,49.97 C19.2 54.68,49.9 R13.1 56.68,50.25 C21.1 R15.1 59.9,50.2 60.85,51.15 60.85,61.05 R16.1 58.75,63.1 57.7,64.15 57.7,64.9 56.25,66.35 Q2.1 C22.2
N129422: length 11.7
  TOP w0.5: C22.1 51.53,72.75 L4.3 50.13,69.12 51.65,67.6 Q2.2
N221560: length 2.8
  TOP w0.5: C18.2 50.57,52.26 XTAL1.4
N828385: length 12.9
  TOP w0.2: U22.19 112.09,92.55 113.05,93.5 113.05,99.96 R31.1
N829333: length 2.3
  TOP w0.5: U31.G7 v2(112.26,104.26)
  BOTTOM w0.5: v2(112.26,104.26) 111.01,104.26 R43.1
N829669: length 2.1
  TOP w0.5: U31.K7 v2(112.2,100.45)
  BOTTOM w0.5: v2(112.2,100.45) 111.15,100.45 R44.1
N829685: length 1.3
  TOP w0.5: U31.H5 U31.G5
N830942: length 2.1
  TOP w0.2: D3.A 122.25,85.86 R29.2
N831005: length 2.1
  TOP w0.2: 120.97,88.65 122.5,88.65 D3.C
N831029: length 2
  TOP w0.2: v2(93.1,104.25) 92.47,104.25 U29.G7
  BOTTOM w0.2: R39.1 92.85,104.5 v2(93.1,104.25)
N831181: length 1.6
  TOP w0.2: U29.K7 v2(93.1,100.45)
  BOTTOM w0.2: R40.1 92.25,100.45 v2(93.1,100.45)
N831646: length 2.1
  TOP w0.2: R28.2 122.25,91.99 122.87,92.61
N831650: length 2.1
  TOP w0.2: D2.C 122.5,94.78 120.97,94.78
N831853: length 2.2
  TOP w0.2: U30.G7 102.74,104.26 v2(102.75,104.25)
  BOTTOM w0.2: R41.1 101.54,104.26 102.74,104.26 v2(102.75,104.25)
N831855: length 2.1
  TOP w0.2: D1.A 122.25,98.12 R27.2
N831859: length 2.1
  TOP w0.2: 120.97,100.91 122.5,100.91 D1.C
N832005: length 2.2
  TOP w0.2: v2(102.75,100.45) 102.7,100.4 101.91,100.4 U30.K7
  BOTTOM w0.2: R42.1 102.7,100.4 v2(102.75,100.45)
N832074: length 2.1
  TOP w0.2: 122.87,80.35 122.25,79.73 R30.2
N832078: length 2.1
  TOP w0.2: D4.C 122.5,82.52 120.97,82.52
N852308: length 9.3
  TOP w0.2: U22.17 112,90 114.05,92.05 114.05,94.83 R32.1
N852494: length 6.2
  TOP w0.2: R33.1 112.81,87.47 U22.15
N852683: length 5.9
  TOP w0.2: R34.1 113.47,84.93 U22.13
N884986: length 5.1
  TOP w0.5: J3.1 C70.2
N885188: length 10.3
  TOP w0.2: J2.1 117.62,68.58 116.4,67.35 115.06,67.35 115.03,67.38 111.38,67.38 L2.2
N885276: length 10.3
  TOP w0.2: L1.2 111.38,51.9 C1.1 115.03,51.9 116.4,51.9 117.6,53.1 J1.1
N885442: length 5.1
  TOP w0.2: L1.1 108.78,56.21 U34.6
N1358395: length 1.8
  BOTTOM w0.2: J5.6 118.5,115.5 R2003.1
N1358407: length 1.7
  BOTTOM w0.2: J5.8 119.1,111.15 R2004.1
N1358411: length 1.6
  BOTTOM w0.2: J5.9 119.45,109.5 R2005.1
N1358515: length 3.2
  BOTTOM w0.2: J5.2 118.2,112.5 R2000.1
N1358527: length 3.1
  BOTTOM w0.2: J5.3 117.94,114.5 R2001.1
N1358539: length 1.7
  BOTTOM w0.2: J5.5 118.15,117.5 R2002.1
N1406173: length 10.8
  TOP w0.2: Y1.3 59.4,77.89 v2(59.4,79.6) 59.95,79.6 60.4,80.05 60.42,80.07 60.42,83.77 60.95,84.3 62.92,84.3 U50.9
  BOTTOM w0.2: R2009.1 v2(59.4,79.6)
N1406200: length 10.2
  TOP w0.2: U50.8 60.82,85.02 59.9,84.1 58.4,84.1 57.9,83.6 v2(57.9,82.25) 56.96,82.25 56.59,82.62
  BOTTOM w0.2: R2009.2 57.9,81.25 v2(57.9,82.25)
N1406547: length 5.9
  TOP w0.3: U50.4 65.65,85.03 v2(65.65,85.95) 65.16,85.46 U50.5
  BOTTOM w0.3: C2008.1 65.4,86.2 v2(65.65,85.95) 65.65,85.18 C2009.1 65.88,83.51 R2006.2
N1406997: length 14.6
  TOP w0.2: U50.10 61.2,83.8 60.85,83.45 60.85,79.6 61.65,78.8 64.2,78.8 64.66,79.25
  TOP w0.3: U50.21 65.66,79.2 v2(65.4,78.95) 64.96,78.95 64.66,79.25 U50.19
  BOTTOM w0.3: v2(65.4,78.95) 65.66,79.2 65.66,79.66 R2007.1
N1421557: length 5.1
  TOP w0.2: U37.6 108.78,71.69 L2.1
N1432081: length 29.5
  TOP w0.102: U2.M12 v1(63.25,92.15)
  TOP w0.2: U11.8 80.62,101.6 v2(81.9,101.6)
  BOTTOM w0.102: 67.94,91.31 67.34,91.31 66.5,92.15 v1(63.25,92.15)
  BOTTOM w0.2: v2(81.9,101.6) 80.75,100.45 80.75,93.31 78.75,91.31 67.94,91.31
N1432096: length 27.8
  TOP w0.1: U2.R11 62.1,90 67.94,90
  TOP w0.2: 67.94,90 68.1,90 69.05,90.95 79.78,90.95 80.75,91.92 80.75,94.77 79.5,96.02 79.5,98.1 79.72,98.33 U11.3
N1432111: length 31.4
  TOP w0.1: 67.94,90.44 67.69,90.19 61.21,90.19 U2.P10
  TOP w0.2: U11.7 80.53,101 79.4,101 79.1,100.7 79.1,95.85 80.35,94.6 80.35,92.08 79.62,91.35 68.85,91.35 67.94,90.44
N1432121: length 35.8
  TOP w0.1: 67.94,87.75 61.65,87.75 U2.T10
  TOP w0.2: 67.94,87.75 69.08,87.75 71.88,90.55 79.95,90.55 80.95,91.55 80.95,91.55 81.15,91.75 81.15,95.39 82.56,96.8 82.56,102.3 82,102.85 80.62,102.85 U11.10
N1438447: length 4.2
  TOP w0.2: SW2.2 63.7,74.15 63.7,75.45 65.06,76.81 U49.3
N1472359: length 4.6
  TOP w0.2: U51.1 70.99,83.97 v2(70.99,84.54)
  BOTTOM w0.2: R2010.2 R2011.1 72.51,83.81 C2010.1 v2(70.99,84.54)
N2993541: length 2.5
  TOP w0.5: R25.2 86.36,132.62 C43.1

## Copper pours and planes (outline as drawn)
0V9 on POWER: 36,110.15 43.55,110.15 46,107.7 46,76.75 48.75,76.75 49.15,77.15 49.15,79.5 49.35,79.7 63.4,79.7 66.05,77.05 68.3,77.05 69.3,78.05 69.3,83 69.45,83.15 71.35,83.15 72.3,82.2 72.3,74.4 71.55,73.65 32.2,73.65 29.2,76.65 29.2,109.55 29.85,110.2 35.95,110.2
1V2 on TOP: 89.15,107.56 89.15,118.05 89,118.2 84.35,118.2 84.2,118.05 84.2,107.44 89.03,107.44
1V2 on POWER: 36.25,117.75 36.25,134.6 47.75,134.6 56.3,126.05 56.3,125.1 63.85,117.55 89.25,117.55 89.25,114.5 80.55,105.8 72.95,105.8 72.95,99.7 72.5,99.25 64.55,99.25 63.65,98.35 63.65,80.25 60.3,76.9 46.25,76.9 46.25,107.75
1V8 on INNER2: 29.95,86.1 29.95,111.95 74.65,111.95 74.65,76.8 39.8,76.8 39.4,77.2 39.3,77.2 39.3,79.05 39.4,79.15 39.4,79.4 36.85,81.95 36.85,84.55 35.75,85.65 30.4,85.65 ; 14 cut-outs
2V5 on TOP: 98.55,107.56 98.55,118.11 98.43,118.23 93.73,118.23 93.6,118.11 93.6,107.56 93.73,107.44 98.43,107.44
2V5 on BOTTOM: 29.6,74.25 28.25,75.6 28.25,135.65 98.6,135.65 98.6,110.1 83.5,110.1 83.35,109.95 81.2,112.1 81.2,112.5 68.9,112.5 65.45,109.05 65.45,105 72,105 72.7,105.7 84.7,105.7 84.7,102.85 85.15,102.4 85.15,96.1 80.67,91.62 67.07,91.62 67.05,91.6 63.85,91.6 63.2,92.25 61.5,92.25 60.65,91.4 60.65,87.2 58.4,84.95 54.45,84.95 52.55,83.05 50.95,83.05 47.8,79.8 38.75,79.8 37.55,78.6 37.55,75.15 36.65,74.25 ; 16 cut-outs
3V3 on TOP: 107.95,107.56 107.95,118.11 107.82,118.23 103.12,118.23 103,118.11 103,107.56 103.12,107.44 107.82,107.44
3V3 on INNER2: 37.85,122.4 30.5,122.4 29.3,123.6 29.3,139.2 86.35,139.2 108.15,117.4 108.15,103.4 107.05,102.3 85.2,102.3 84.2,101.3 84.2,71.2 83.55,70.55 36.8,70.55 35.85,71.5 35.85,79.25 36.3,79.7 39.05,79.7 39.35,79.4 39.35,77 39.85,76.5 67.85,76.5 74.95,83.6 74.95,93.2 74.25,93.9 65.5,93.9 65.15,93.55 63.1,93.55 62.45,94.2 62.45,97.9 63.2,98.65 64.7,98.65 65.15,98.2 70.55,98.2 71,98.65 71,100.35 70,101.35 69.9,101.35 69.9,103.7 70.35,104.15 71.05,104.15 71.05,109.9 74.95,109.9 74.95,112.35 74.8,112.5 53,112.5 52.9,112.4 49.45,115.85 49.45,115.9 49.4,115.95 41.25,115.95 39.65,117.55 39.65,120.2 39.85,120.4
GND EARTH on TOP (solid shape): 124.87,56.82 124.87,49.29 117.25,49.29 117.25,51.83 119.64,51.83 122.97,53.1 119.64,54.37 117.63,54.37 116.26,53.01 114.23,53.01 114.23,56.82 114.48,57.07 124.62,57.07
GND EARTH on TOP: 117.25,64.77 117.25,67.31 119.64,67.31 122.97,68.58 119.64,69.85 117.63,69.85 116.26,68.48 114.23,68.48 114.23,72.29 114.48,72.55 124.62,72.55 124.87,72.29 124.87,64.77
GND EARTH on GND: 115.32,48.89 115.32,77.5 119.6,81.78 119.6,109.7 121.85,111.95 121.85,117.6 119.6,119.85 119.6,126.4 109.45,136.55 82.95,136.55 81,134.6 81,126 80.5,125.5 78.4,125.5 78,125.9 78,138.1 81.45,141.55 125.09,141.55 125.09,49.15 124.83,48.89
V12N on POWER: 104.72,73.03 107.15,70.6 111.95,70.6 112.55,70 112.55,49.5 111.95,48.9 22.5,48.9 22.25,49.15 22.25,54 0.9,54 0.65,54.25 0.65,84.3 13,84.3 39.4,57.9 99.05,57.9 101.25,60.1 101.25,72.45 101.82,73.03
VCC on POWER: 165.5,138.32 164.18,141.5 161,142.82 128.73,142.82 126.26,141.8 125.23,139.32 125.23,49.1 124.89,48.76 22.43,48.76 22.09,49.1 22.09,53.84 0.84,53.84 0.5,54.18 0.5,156.63 0.84,156.98 22.09,156.98 22.09,163.21 22.43,163.56 124.91,163.56 125.23,163.27 125.23,155.32 126.26,152.85 128.73,151.82 161,151.82 170.55,147.87 174.5,138.32 174.5,127.6 170.55,118.05 161,114.1 157.65,114.1 154.47,112.78 153.15,109.6 153.15,80.85 154.18,78.38 156.65,77.35 158.55,77.35 158.55,66.15 139.15,66.15 139.15,77.35 140.65,77.35 143.12,78.38 144.15,80.85 144.15,109.6 148.1,119.15 157.65,123.1 161,123.1 164.18,124.42 165.5,127.6 ; 1 cut-out
0 on TOP: 93.6,107.2 98.7,107.2 98.9,107.4 98.9,118.1 99,118.2 102.6,118.2 102.8,118 102.8,95.9 102.7,95.8 98.4,95.8 98.2,96 98.2,103 98,103.2 93.7,103.2 93.6,103.3
0 on TOP: 103,107.2 108.1,107.2 108.3,107.4 108.3,118.1 108.4,118.2 112,118.2 112.2,118 112.2,95.9 112.1,95.8 107.8,95.8 107.6,96 107.6,103 107.4,103.2 103.1,103.2 103,103.3
0 on TOP: 40.55,50.15 40.55,66 40.05,66.5 29.2,66.5 28.45,65.75 28.45,50.15 29.4,49.2 39.6,49.2
0 on TOP: 84.2,107.2 89.3,107.2 89.5,107.4 89.5,118.1 89.6,118.2 93.2,118.2 93.4,118 93.4,95.9 93.4,95.9 93.4,93.8 93.2,93.6 89.2,93.6 88.8,94 88.8,103 88.6,103.2 84.3,103.2 84.2,103.3
0 on GND: 165.5,138.32 164.18,141.5 161,142.82 128.73,142.82 126.26,141.8 125.23,139.32 125.23,49.1 124.89,48.76 22.43,48.76 22.09,49.1 22.09,53.84 0.84,53.84 0.5,54.18 0.5,156.63 0.84,156.98 22.09,156.98 22.09,163.21 22.43,163.56 124.91,163.56 125.23,163.27 125.23,155.32 126.26,152.85 128.73,151.82 161,151.82 170.55,147.87 174.5,138.32 174.5,127.6 170.55,118.05 161,114.1 157.65,114.1 154.47,112.78 153.15,109.6 153.15,80.85 154.18,78.38 156.65,77.35 158.55,77.35 158.55,66.15 139.15,66.15 139.15,77.35 140.65,77.35 143.12,78.38 144.15,80.85 144.15,109.6 148.1,119.15 157.65,123.1 161,123.1 164.18,124.42 165.5,127.6 ; 2 cut-outs
0 on INNER2: 61.45,53.4 61.45,-3.35 130.85,-3.35 130.85,53.4
0 on INNER2: 139.15,66.15 139.15,77.35 140.65,77.35 143.13,78.37 144.15,80.85 144.15,109.6 148.1,119.15 157.65,123.1 161,123.1 164.18,124.42 165.5,127.6 165.5,138.32 164.18,141.5 161,142.82 128.73,142.82 126.39,141.93 125.25,139.7 125.25,141.15 17.7,141.15 9.75,133.2 0.95,133.2 0.5,133.65 0.5,156.63 0.84,156.97 22.09,156.97 22.09,163.21 22.43,163.55 48.35,163.55 50.83,164.58 51.85,167.06 51.85,203.2 50.83,205.68 48.35,206.7 15,206.7 15,233.75 98.2,233.75 98.2,206.7 64.35,206.7 61.87,205.68 60.85,203.2 60.85,167.06 61.87,164.58 64.35,163.55 124.91,163.55 125.23,163.27 125.23,155.32 126.25,152.85 128.73,151.82 161,151.82 170.55,147.87 174.5,138.32 174.5,127.6 170.55,118.05 161,114.1 157.65,114.1 154.47,112.78 153.15,109.6 153.15,80.85 154.17,78.37 156.65,77.35 158.55,77.35 158.55,66.15
Net_7 on TOP (solid shape): 10.02,59.52 10.03,59.48 10.03,59.4 10.03,59.28 10.03,58.58 10.03,57.35 10.04,56.07 10.04,55.93 10.05,55.79 10.03,55.61 10.01,55.6 9.96,55.59 9.84,55.59 9.66,55.59 9.45,55.59 9.23,55.59 8.83,55.59 8.62,55.6 7.9,56.66 7.89,56.84 7.88,57 7.88,57.12 8.53,57.12 8.53,57.08 8.61,56.51 8.63,56.44 8.66,56.37 8.69,56.32 8.72,56.26 8.75,56.22 8.79,56.18 8.88,56.12 9.28,56.07 9.35,56.14 9.35,57.7 9.32,57.78 9.21,57.99 9.15,58.04 9.09,58.1 9.01,58.1 8.94,58.1 8.83,58.06 8.78,58.02 8.75,57.99 8.72,57.95 8.7,57.92 8.67,57.88 8.65,57.84 8.64,57.8 8.62,57.75 8.56,57.4 8.53,57.16 8.53,57.12 7.88,57.12 7.88,57.2 7.88,57.29 7.89,57.37 7.89,57.44 7.9,57.51 7.9,57.57 7.92,57.67 9.31,58.49 9.35,58.77 9.35,59.5 9.89,59.57
Net_8 on TOP (solid shape): 6.1,58.52 6.4,57.99 6.45,57.82 6.46,56.39 6.46,56.25 6.46,56.13 6.46,55.87 6.49,55.69 6.49,55.65 6.48,55.63 6.45,55.61 6.4,55.6 6.31,55.59 6.18,55.59 5.56,55.59 5.38,55.59 5.24,55.59 5.14,55.6 5.06,55.6 5,55.61 4.96,55.63 4.87,55.67 4.82,55.7 4.78,55.72 4.74,55.75 4.71,55.78 4.67,55.81 4.62,55.88 4.57,55.96 4.45,56.49 4.45,56.54 5.09,56.54 5.09,56.48 5.11,56.38 5.46,56.08 5.56,56.08 5.64,56.08 5.75,56.11 5.78,56.14 5.8,56.4 5.8,56.85 5.79,57.09 5.78,57.1 5.62,57.12 5.56,57.12 5.17,56.88 5.14,56.84 5.13,56.8 5.11,56.75 5.1,56.7 5.09,56.65 5.09,56.59 5.09,56.54 4.45,56.54 4.46,56.66 4.48,56.79 4.55,56.98 4.59,57.05 5.44,57.56 5.49,57.56 5.77,57.74 5.75,57.81 5.74,57.88 5.71,57.94 5.69,57.99 5.65,58.04 5.61,58.08 5.57,58.11 5.46,58.16 5.39,58.17 5.26,58.17 5.18,58.16 4.7,58.06 4.7,58.44 4.74,58.48
Net_9 on TOP (solid shape): 3,58.64 3.07,58.64 3.24,58.28 3.22,58.09 2.91,58.1 2.78,58.1 2.68,58.06 2.27,57.48 2.26,57.44 2.25,57.31 2.24,57.17 2.25,56.86 2.25,56.81 2.26,56.73 2.28,56.67 2.46,56.29 2.57,56.2 2.64,56.16 2.74,56.11 3.15,56.14 3.18,56.14 3.2,56.14 3.22,56.12 3.23,56.1 3.23,56.07 3.24,56.02 3.24,55.87 3.21,55.63 3.18,55.61 2.79,55.56 1.98,55.84 1.9,55.92 1.56,57.16 1.65,57.7 1.91,58.2 1.94,58.23 2.02,58.32 2.07,58.36 2.16,58.44 2.22,58.48 2.58,58.63 2.65,58.64
Net_10 on TOP (solid shape): outline of 83 points within 11.44,55.56 13.53,58.65
Net_11 on TOP (solid shape): 19.74,58.64 19.85,58.64 19.93,58.64 20,58.63 20.04,58.61 20.07,58.58 20.09,58.54 20.1,58.49 20.11,58.32 19.97,58.08 19.85,58.1 19.76,58.11 19.67,58.1 19.59,58.08 19.52,58.05 19.46,58.02 19.43,57.99 19.36,57.93 19.31,57.86 19.1,57.18 19.1,57.04 19.1,56.92 19.12,56.78 19.19,56.54 19.21,56.49 19.23,56.44 19.26,56.4 19.29,56.35 19.32,56.3 19.36,56.27 19.42,56.22 19.68,56.1 20.11,56.1 20.11,55.86 20.11,55.75 20.1,55.71 20.09,55.68 20.08,55.65 20.07,55.64 20.03,55.61 19.98,55.6 19.92,55.58 19.85,55.57 19.77,55.57 19.69,55.56 19.61,55.56 19.53,55.56 19.37,55.58 18.97,55.74 18.78,55.91 18.57,56.26 18.45,56.81 18.44,56.95 18.44,57.08 18.44,57.21 18.73,58.13 18.79,58.22 18.83,58.26 18.91,58.34 19.04,58.46 19.14,58.52 19.65,58.65
Net_12 on TOP (solid shape): 22.56,58.64 22.64,58.64 23.36,57.46 23.37,57.28 23.36,57.09 23.17,56.93 22.98,56.93 22.63,56.93 21.98,56.93 22.06,56.34 22.09,56.3 22.12,56.27 22.15,56.23 22.18,56.21 22.23,56.18 22.27,56.15 22.37,56.11 23.08,56.14 23.12,56.14 23.15,56.13 23.17,56.12 23.18,56.09 23.18,56.05 23,55.62 22.94,55.6 22.89,55.59 22.82,55.58 22.74,55.58 22.58,55.57 22.42,55.56 22.3,55.57 22.05,55.62 21.85,55.71 21.78,55.76 21.66,55.87 21.58,55.96 21.44,56.18 21.32,56.58 21.27,57.12 21.27,57.18 21.32,57.5 21.95,57.5 21.97,57.41 21.99,57.4 22.02,57.39 22.18,57.39 22.39,57.39 22.59,57.4 22.69,57.4 22.74,57.64 22.73,57.7 22.48,58.13 22.45,58.14 22.43,58.15 22.4,58.16 22.37,58.16 22.33,58.15 22.3,58.15 22.06,57.94 22.01,57.83 21.98,57.74 21.97,57.69 21.96,57.62 21.95,57.5 21.32,57.5 21.53,58.14 21.78,58.44 21.84,58.48 22.45,58.65
Net_13 on TOP (solid shape): 16.41,58.63 16.91,58.23 17.01,57.89 17.02,57.85 17.02,57.79 17.03,57.7 17.03,57.59 17.03,57.46 17.04,57.28 17.04,57.08 17.04,56.54 17.04,56.28 17.04,56.08 17.04,55.92 17.03,55.72 17.03,55.64 17.02,55.61 16.86,55.59 16.49,55.59 16.45,55.6 16.42,55.6 16.4,55.61 16.38,55.62 16.37,55.66 16.37,55.91 16.37,56.04 16.37,56.18 16.37,56.33 16.37,56.67 16.37,57.64 15.98,58.09 15.65,58.09 15.62,58.04 15.61,58 15.61,57.82 15.61,57.46 15.61,55.64 14.98,55.63 14.97,55.73 14.97,55.84 14.96,56 14.96,56.22 14.96,56.87 14.96,57.32 14.95,57.53 15.04,58.63 15.16,58.64 15.71,58.64
V+12 on TOP: 93.6,103 97.9,103 98,102.9 98,96 97.8,95.8 93.7,95.8 93.6,95.9
V+12 on TOP: 103,103 107.3,103 107.4,102.9 107.4,96 107.2,95.8 103.1,95.8 103,95.9
V+12 on TOP: 84.2,103 88.5,103 88.6,102.9 88.6,94 88.2,93.6 84.5,93.6 84.2,93.9
V+12 on INNER2: 36.45,70.25 83.8,70.25 84.5,70.95 84.5,101.55 85,102.05 110.65,102.05 114,98.7 114,56.35 111.45,53.8 29.5,53.8 27.7,55.6 1.05,55.6 0.65,56 0.65,79.2 1.05,79.6 27.1,79.6

Small or netless copper shapes (teardrops, artwork): 2 on TOP
