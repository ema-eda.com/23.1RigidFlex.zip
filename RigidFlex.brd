# Allegro board RigidFlex.brd (continued)
## Nets (continued)
0: C3.2 C4.2 C5.2 C6.2 C7.2 C8.2 C9.2 C10.2 C12.1 C13.1 C14.1 C15.1 C16.1 C23.2 C24.2 C25.2 C26.2 C27.2 C28.2 C29.2 C30.2 C31.1 C32.1 C33.1 C36.1 C37.1 C38.2 C39.1 C40.1 C44.2 C45.2 C46.2 C47.2 C48.2 C49.2 C50.2 C51.2 C52.2 C53.2 C54.2 C55.2 C62.2 C63.2 C64.2 C65.2 C66.2 C67.2 C68.1 C72.1 C73.2 C74.2 C75.2 C76.2 C77.2 C78.2 C79.2 C80.2 C81.2 C82.2 C83.2 C84.2 C85.2 C86.2 C87.2 C88.2 C89.2 C90.2 C91.2 C92.2 C93.2 C94.2 C95.2 C96.2 C97.2 C98.2 C99.2 C100.2 C101.2 C102.2 C103.2 C104.2 C105.2 C106.2 C107.2 C108.2 C109.2 C110.2 C111.2 C112.2 C113.2 C114.2 C115.2 C116.2 C117.2 C118.2 C119.2 C120.2 C121.2 C122.2 C123.2 C124.2 C125.2 C126.2 C127.2 C128.2 C129.2 C130.2 C131.2 C132.2 C133.2 C134.2 C135.2 C136.2 C137.2 C138.2 C139.2 C140.2 C141.2 C142.2 C143.2 C144.2 C145.2 C146.2 C147.2 C148.2 C149.2 C150.2 C151.2 C152.2 C153.2 C154.2 C155.2 C156.2 C157.2 C158.2 C159.2 C160.2 C161.2 C162.2 C163.2 C164.2 C165.2 C166.2 C167.2 C168.2 C169.2 C170.2 C171.2 C172.2 C173.2 C174.2 C175.2 C176.2 C177.2 C178.2 C179.2 C180.2 C181.2 C182.2 C183.2 C184.2 C185.2 C186.2 C187.2 C188.2 C189.2 C190.2 C191.2 C192.2 C193.2 C194.2 C195.2 C196.2 C197.2 C198.2 C199.2 C200.2 C201.2 C202.2 C2000.2 C2001.2 C2002.2 C2003.2 C2004.2 C2005.2 C2006.2 C2007.1 C2008.2 C2009.2 C2010.2 C2011.2 C2012.2 C2013.2 C2014.2 C2015.2 C2016.2 J5.4 J5.7 J6.C1 J6.C2 J6.C23 J6.C24 J6.F1 J6.F2 J6.F23 J6.F24 J7.39 J7.40 J7.41 J7.42 J7.43 J7.44 J7.45 J7.46 J7.47 J7.48 J7.49 J7.50 J7.89 J7.90 J7.91 J7.92 J7.93 J7.94 J7.95 J7.96 J7.97 J7.98 J7.99 J7.100 J7.139 J7.140 J7.141 J7.142 J7.143 J7.144 J7.145 J7.146 J7.147 J7.148 J7.149 J7.150 J7.189 J7.190 J7.191 J7.192 J7.193 J7.194 J7.195 J7.196 J7.197 J7.198 J7.199 J7.200(PIN200) P1.1 P1.5 P1.9(PIN9) P1.13 Q4.2(E) Q5.2(E) Q6.2(E) Q7.2(E) R12.1 R14.1 R18.1 R23.1 R24.1 R25.1 R39.2 R40.2 R41.2 R42.2 R43.2 R44.2 R51.2 R52.1 R2011.2 SW2.1 U1.A1 U1.A16 U1.B7 U1.B11 U1.D4 U1.D13 U1.E9 U1.G2 U1.G8 U1.G15 U1.H7 U1.H9 U1.H12 U1.J5 U1.J8 U1.K7 U1.K9 U1.L2 U1.L15 U1.M8 U1.N13 U1.P3 U1.R6 U1.R10 U1.T1 U1.T16 U2.A1 U2.A16 U2.B7 U2.B11 U2.D4 U2.D13 U2.E9 U2.G2 U2.G8 U2.G15 U2.H7 U2.H9 U2.H12 U2.J5 U2.J8 U2.K7 U2.K9 U2.L2 U2.L15 U2.M8 U2.N13 U2.P3 U2.R6 U2.R10 U2.T1 U2.T16 U3.2 U3.3 U3.6 U3.7 U4.5 U4.10 U4.19 U4.24 U5.2 U5.4(TGND) U6.4 U6.10 U6.15 U6.21 U6.24 U6.25(G\) U6.28 U6.34 U6.39 U6.45 U7.10 U8.1 U8.4 U8.10 U8.15 U8.21 U8.28 U8.34 U8.39 U8.45 U8.48 U9.4 U9.10 U9.15 U9.21 U9.24 U9.25(G\) U9.28 U9.34 U9.39 U9.45 U10.11 U11.11 U12.A3 U12.A7 U12.B2 U12.B8 U12.D2 U12.D8 U12.E3 U12.E7 U12.F2 U12.F8 U12.H2 U12.H8(VSSQ#H8) U12.J3 U12.J7 U12.N1 U12.P9 U13.A3 U13.A7 U13.B2 U13.B8 U13.D2 U13.D8 U13.E3 U13.E7 U13.F2 U13.F8 U13.H2 U13.H8(VSSQ#H8) U13.J3 U13.J7 U13.N1 U13.P9 U22.1 U22.10 U29.A5 U29.A6 U29.A7 U29.B5 U29.B6 U29.B7 U29.C5 U29.C6 U29.C7 U29.D5 U29.D6 U29.D7 U29.E1 U29.E2 U29.E3 U29.E4 U29.E5 U29.E6 U29.E7 U29.F1 U29.F2 U29.F3 U29.F4 U29.F5 U29.F6 U29.F7 U29.G1 U29.G2 U29.G3 U29.G4 U29.G6 U29.H6 U29.J5 U29.J6 U29.K5 U29.K6 U29.L6 U29.L7 U30.A5 U30.A6 U30.A7 U30.B5 U30.B6 U30.B7 U30.C5 U30.C6 U30.C7 U30.D5 U30.D6 U30.D7 U30.E1 U30.E2 U30.E3 U30.E4 U30.E5 U30.E6 U30.E7 U30.F1 U30.F2 U30.F3 U30.F4 U30.F5 U30.F6 U30.F7 U30.G1 U30.G2 U30.G3 U30.G4 U30.G6 U30.H6 U30.J5 U30.J6 U30.K5 U30.K6 U30.L6 U30.L7 U31.A5 U31.A6 U31.A7 U31.B5 U31.B6 U31.B7 U31.C5 U31.C6 U31.C7 U31.D5 U31.D6 U31.D7 U31.E1 U31.E2 U31.E3 U31.E4 U31.E5 U31.E6 U31.E7 U31.F1 U31.F2 U31.F3 U31.F4 U31.F5 U31.F6 U31.F7 U31.G1 U31.G2 U31.G3 U31.G4 U31.G6 U31.H6 U31.J5 U31.J6 U31.K5 U31.K6 U31.L6 U31.L7 U32.1 U32.3 U32.7 U32.10 U32.20 U33.3 U35.1 U35.3 U35.7 U35.10 U35.20 U36.3 U38.1 U38.10 U39.1 U39.10 U40.16 U40.24 U41.16 U41.24 U42.16 U42.24 U43.16 U43.24 U44.16 U44.24 U45.16 U45.24 U46.16 U46.24 U47.16 U47.24 U48.10 U49.1 U50.1 U50.2 U50.3 U50.12 U50.13 U50.14 U50.15 U50.17 U50.18 U50.20 U50.22 U50.23 U50.25 U50.29 U50.33 U51.4 U51.8
A0: J6.B8 U9.36
A1: J6.B7 U9.35
A2: J6.B6 U9.33
A3: J6.B5 U9.32
A4: J6.B4 U9.30
A5: J6.B3 U9.29
A6: J6.B2 U9.27
A7: J6.B1 U9.26
A8: J6.B16 U8.47
A9: J6.B15 U8.46
A10: J6.B14 U8.44
A11: J6.B13 U8.43
A12: J6.B12 U8.41
A13: J6.B11 U8.40
A14: J6.B10 U8.38
A15: J6.B9 U8.37
A16: J6.B24 U6.36
A17: J6.B23 U6.35
A18: J6.B22 U6.33 U7.6
A19: J6.B21 U6.32 U7.5
A20: J6.B20 U6.30 U7.4
A21: J6.B19 U6.29 U7.3
A22: J6.B18 U6.27 U7.2
A23: J6.B17 U6.26
AEN/: J6.E3 U7.7
BRD/: U7.13 U48.7
BRESET: U7.12 U48.8
BUF_OUT: C41.2 R50.1
BWR/: U7.14 U48.6
CENTER-TAP: C41.1 R21.2
CLKC: R26.1 U1.C3
CLOCK+: U1.H4 U2.J11 U50.31
CLOCK-: U1.H3 U2.J12 U50.30
CONF_SW0: RN1.1 SW1.1 U1.T11
CONF_SW1: RN1.2 SW1.2 U1.R11
CONF_SW2: RN1.3 SW1.3 U1.N8
CONF_SW3: RN1.4 SW1.4 U1.M9
D0: J6.E8 U8.26 U9.37
D1: J6.E9 U8.27 U9.38
D2: J6.E10 U8.29 U9.40
D3: J6.E11 U8.30 U9.41
D4: J6.E12 U8.32 U9.43
D5: J6.E13 U8.33 U9.44
D6: J6.E14 U8.35 U9.46
D7: J6.E15 U8.36 U9.47
D8: J6.E24 U6.47
D9: J6.E23 U6.46
D10: J6.E22 U6.44
D11: J6.E21 U6.43
D12: J6.E20 U6.41
D13: J6.E19 U6.40
D14: J6.E18 U6.38
D15: J6.E17 U6.37
D+: C2001.1 R2000.2 U2.N11
D-: C2000.1 R2001.2 U2.P11
DATA0+: U1.B6 U2.B5
DATA0-: U1.A6 U2.A5
DATA1+: U1.D6 U2.D5
DATA1-: U1.C6 U2.C5
DATA1.CLKA: U1.K5 U32.11 U35.11 U38.11
DATA1.VD0: RN3.1 U1.M2
DATA1.VD1: RN3.2 U1.M1
DATA1.VD2: RN3.3 U1.N3
DATA1.VD3: RN3.4 U1.N1
DATA1.VD4: RN2.1 U1.P2
DATA1.VD5: RN2.2 U1.P1
DATA1.VD6: RN2.3 U1.R2
DATA1.VD7: RN2.4 U1.R1
DATA1.WSTAT_L: U1.J6 U22.11
DATA2+: U1.B5 U2.D6
DATA2-: U1.A5 U2.C6
DATA3+: U1.D5 U2.B6
DATA3-: U1.C5 U2.A6
DATA.BA0: U1.H16 U6.13 U8.2 U9.13
DATA.BA1: U1.H15 U6.14 U8.3 U9.14
DATA.BA2: U1.G14 U6.16 U8.5 U9.16
DATA.BA3: U1.G16 U6.17 U8.6 U9.17
DATA.BD0: U1.F16 U9.2
DATA.BD1: U1.F15 U9.3
DATA.BD2: U1.E16 U9.5
DATA.BD3: U1.E15 U9.6
DATA.BD4: U1.E13 U9.8
DATA.BD5: U1.E12 U9.9
DATA.BD6: U1.B15 U9.11
DATA.BD7: U1.B16 U9.12
DATA.BD8: U1.F12 U6.2 U8.23
DATA.BD9: U1.G11 U6.3 U8.22
DATA.BD12: U1.F13 U6.8 U8.17
DATA.BD13: U1.F14 U6.9 U8.16
DATA.BD14: U1.C15 U6.11 U8.14
DATA.BD15: U1.C16 U6.12 U8.13
DATA.CLKB: J6.E16 U1.J16
DDIR: U6.1 U7.1 U8.24 U9.1
DDR_A0: U2.C1 U12.M8 U13.M8
DDR_A1: U2.D1 U12.M3 U13.M3
DDR_A2: U2.E1 U12.M7 U13.M7
DDR_A3: U2.F1 U12.N2 U13.N2
DDR_A4: U2.G1 U12.N8 U13.N8
DDR_A5: U2.H1 U12.N3 U13.N3
DDR_A6: U2.J1 U12.N7 U13.N7
DDR_A7: U2.K1 U12.P2 U13.P2
DDR_A8: U2.L1 U12.P8 U13.P8
DDR_A9: U2.M1 U12.P3 U13.P3
DDR_A10: U2.N1 U12.M2 U13.M2
DDR_A11: U2.P1 U12.P7 U13.P7
DDR_A12: U2.R1 U12.R2 U13.R2
DDR_BA0: U2.M2 U12.L2 U13.L1
DDR_BA1: U2.P2 U12.L3 U13.L3
DDR_BA2: U2.R2 U12.L1 U13.L2
DDR_CAS: U2.T3 U12.L7 U13.L7
DDR_CK_N: U2.T5 U12.J8 U13.J8
DDR_CK_P: U2.R5 U12.K8 U13.K8
DDR_CKE: U2.T4 U12.K2 U13.K2
DDR_CS1: U2.P5 U12.L8
DDR_CS2: U2.N5 U13.L8
DDR_DQ0: U2.F5 U12.G8
DDR_DQ1: U2.C2 U12.G2
DDR_DQ2: U2.F4 U12.H7
DDR_DQ3: U2.E4 U12.H3
DDR_DQ4: U2.D3 U12.H1
DDR_DQ5: U2.G5 U12.H9
DDR_DQ6: U2.C3 U12.F1
DDR_DQ7: U2.G3 U12.F9
DDR_DQ8: U2.E2 U12.C8
DDR_DQ9: U2.B3 U12.C2
DDR_DQ10: U2.F3 U12.D7
DDR_DQ11: U2.B1 U12.D3
DDR_DQ12: U2.B2 U12.D1
DDR_DQ13: U2.F2 U12.D9
DDR_DQ14: U2.A2 U12.B1
DDR_DQ15: U2.E3 U12.B9
DDR_DQ16: U2.L3 U13.G8
DDR_DQ17: U2.H5 U13.G2
DDR_DQ18: U2.K5 U13.H7
DDR_DQ19: U2.K2 U13.H3
DDR_DQ20: U2.H3 U13.H1
DDR_DQ21: U2.L5 U13.H9
DDR_DQ22: U2.H2 U13.F1
DDR_DQ23: U2.M4 U13.F9
DDR_DQ24: U2.M5 U13.C8
DDR_DQ25: U2.J3 U13.C2
DDR_DQ26: U2.L4 U13.D7
DDR_DQ27: U2.K3 U13.D3
DDR_DQ28: U2.H4 U13.D1
DDR_DQ29: U2.N3 U13.D9
DDR_DQ30: U2.J4 U13.B1
DDR_DQ31: U2.N4 U13.B9
DDR_LDM1: U2.P6 U12.F3
DDR_LDM2: U2.N6 U13.F3
DDR_LDQS1: U2.M6 U12.F7
DDR_LDQS2: U2.T6 U13.F7
DDR_ODT1: U2.T7 U12.K9
DDR_ODT2: U2.R7 U13.K9
DDR_RAS: U2.P7 U12.K7 U13.K7
DDR_UDM1: U2.M7 U12.B3
DDR_UDM2: U2.L7 U13.B3
DDR_UDQS1_N: U2.T9 U12.A8
DDR_UDQS1_P: U2.R9 U12.B7
DDR_UDQS2_N: U2.P9 U13.B7
DDR_UDQS2_P: U2.N9 U13.A8
DDR_WE: U2.P8 U12.K3 U13.K3
DDS.DATA0: U2.B10 U4.4
DDS.DATA1: U2.C10 U4.3
DDS.DATA2: U2.E10 U4.2
DDS.DATA3: U2.F10 U4.1
DDS.DATA4: U2.E11 U4.28
DDS.DATA5: U2.D11 U4.27
DDS.DATA6: U2.C11 U4.26
DDS.DATA7: U2.A11 U4.25
DDS.FQUD: U2.B12 U4.8
DDS.RESET: U2.A13 U4.22
DDS.WCLK: U2.A14 U4.7
DDS_CLK: L4.2 U4.9
DDS_OUT: C34.2 C36.2 L5.1 U4.20
DEN/: U6.48 U7.17 U9.48
DHEN/: U7.18 U8.25(G\)
DI: P1.7 U1.C12
DIFF1+: U1.D16 U6.5 U8.20
DIFF1-: U1.D14 U6.6 U8.19
DQ0: U32.19 U38.12
DQ1: U32.18 U38.13
DQ2: U32.17 U38.14
DQ3: U32.16 U38.15
DQ4: U32.15 U38.16
DQ5: U32.14 U38.17
DQ6: U32.13 U38.18
DQ7: U32.12 U38.19
DQ8: U35.19 U39.12
DQ9: U35.18 U39.13
DQ10: U35.17 U39.14
DQ11: U35.16 U39.15
DQ12: U35.15 U39.16
DQ13: U35.14 U39.17
DQ14: U35.13 U39.18
DQ15: U35.12 U39.19
E: U1.C1
FPGA/: U7.15 U48.5
GAIN: U1.J4 U33.6 U36.6
HS/: U7.16 U48.4
JTAG_D0: P1.8 U2.E14
LED1: Q4.1 R31.2
LED2: Q5.1 R32.2
LED3: Q6.1 R33.2
LED4: Q7.1 R34.2
LPF_OUT: C42.1 R17.2 R18.2
MEMORY.CTRL.RCS0: J7.26 U1.J1 U40.22 U44.22
MEMORY.CTRL.RCS1: J7.76 U1.G3 U41.22 U45.22
MEMORY.CTRL.RCS2: J7.126 U1.F2 U42.22 U46.22
MEMORY.CTRL.RCS3: J7.176 U1.G6 U43.22 U47.22
MEMORY.CTRL.RWE: J7.27 J7.77 J7.127 J7.177 U1.M11 U40.29(W\E\) U41.29(W\E\) U42.29(W\E\) U43.29(W\E\) U44.29(W\E\) U45.29(W\E\) U46.29(W\E\) U47.29(W\E\)
MEMORY.RA0: J7.1 J7.51 J7.101 J7.151 U1.P5 U40.12 U41.12 U42.12 U43.12 U44.12 U45.12 U46.12 U47.12
MEMORY.RA1: J7.2 J7.52 J7.102 J7.152 U1.P10 U40.11 U41.11 U42.11 U43.11 U44.11 U45.11 U46.11 U47.11
MEMORY.RA2: J7.3 J7.53 J7.103 J7.153 U1.N11 U40.10 U41.10 U42.10 U43.10 U44.10 U45.10 U46.10 U47.10
MEMORY.RA3: J7.4 J7.54 J7.104 J7.154 U1.R9 U40.9 U41.9 U42.9 U43.9 U44.9 U45.9 U46.9 U47.9
MEMORY.RA4: J7.5 J7.55 J7.105 J7.155 U1.P8 U40.8 U41.8 U42.8 U43.8 U44.8 U45.8 U46.8 U47.8
MEMORY.RA5: J7.6 J7.56 J7.106 J7.156 U1.R7 U40.7 U41.7 U42.7 U43.7 U44.7 U45.7 U46.7 U47.7
MEMORY.RA6: J7.7 J7.57 J7.107 J7.157 U1.P6 U40.6 U41.6 U42.6 U43.6 U44.6 U45.6 U46.6 U47.6
MEMORY.RA7: J7.8 J7.58 J7.108 J7.158 U1.N5 U40.5 U41.5 U42.5 U43.5 U44.5 U45.5 U46.5 U47.5
MEMORY.RA8: J7.9 J7.59 J7.109 J7.159 U1.L8 U40.27 U41.27 U42.27 U43.27 U44.27 U45.27 U46.27 U47.27
MEMORY.RA9: J7.10 J7.60 J7.110 J7.160 U1.M6 U40.26 U41.26 U42.26 U43.26 U44.26 U45.26 U46.26 U47.26
MEMORY.RA10: J7.11 J7.61 J7.111 J7.161 U1.T10 U40.23 U41.23 U42.23 U43.23 U44.23 U45.23 U46.23 U47.23
MEMORY.RA11: J7.12 J7.62 J7.112 J7.162 U1.P11 U40.25 U41.25 U42.25 U43.25 U44.25 U45.25 U46.25 U47.25
MEMORY.RA12: J7.13 J7.63 J7.113 J7.163 U1.T9 U40.4 U41.4 U42.4 U43.4 U44.4 U45.4 U46.4 U47.4
MEMORY.RA13: J7.14 J7.64 J7.114 J7.164 U1.T8 U40.28 U41.28 U42.28 U43.28 U44.28 U45.28 U46.28 U47.28
MEMORY.RA14: J7.15 J7.65 J7.115 J7.165 U1.T7 U40.3 U41.3 U42.3 U43.3 U44.3 U45.3 U46.3 U47.3
MEMORY.RA15: J7.16 J7.66 J7.116 J7.166 U1.T6 U40.31 U41.31 U42.31 U43.31 U44.31 U45.31 U46.31 U47.31
MEMORY.RA16: J7.17 J7.67 J7.117 J7.167 U40.2 U41.2 U42.2 U43.2 U44.2 U45.2 U46.2 U47.2
MEMORY.RD0: J7.18 J7.68 J7.118 J7.168 U1.R15 U40.13 U41.13 U42.13 U43.13 U44.13 U45.13 U46.13 U47.13
MEMORY.RD1: J7.19 J7.69 J7.119 J7.169 U1.R16 U40.14 U41.14 U42.14 U43.14 U44.14 U45.14 U46.14 U47.14
MEMORY.RD2: J7.20 J7.70 J7.120 J7.170 U1.R14 U40.15 U41.15 U42.15 U43.15 U44.15 U45.15 U46.15 U47.15
MEMORY.RD3: J7.21 J7.71 J7.121 J7.171 U1.T15 U40.17 U41.17 U42.17 U43.17 U44.17 U45.17 U46.17 U47.17
MEMORY.RD4: J7.22 J7.72 J7.122 J7.172 U1.T14 U40.18 U41.18 U42.18 U43.18 U44.18 U45.18 U46.18 U47.18
MEMORY.RD5: J7.23 J7.73 J7.123 J7.173 U1.T13 U40.19 U41.19 U42.19 U43.19 U44.19 U45.19 U46.19 U47.19
MEMORY.RD6: J7.24 J7.74 J7.124 J7.174 U1.R12 U40.20 U41.20 U42.20 U43.20 U44.20 U45.20 U46.20 U47.20
MEMORY.RD7: J7.25 J7.75 J7.125 J7.175 U1.T12 U40.21 U41.21 U42.21 U43.21 U44.21 U45.21 U46.21 U47.21
MRD/: J6.E4 U7.8
MWR/: J6.E5 U7.9
N00036_USER_DESIGN_OUTPUTS0_DAAMP0: L8.2 R53.1 R54.1 U32.5 U32.8 U33.5(VL)
N00036_USER_DESIGN_OUTPUTS0_DAAMP1: L10.2 R55.1 R56.1 U35.5 U35.8 U36.5(VL)
N00038_USER_DESIGN_OUTPUTS0_DAAMP0: C198.1 L7.2 U32.4
N00038_USER_DESIGN_OUTPUTS0_DAAMP1: C201.1 L9.2 U35.4
N00044_USER_DESIGN_OUTPUTS0_DAAMP0: U33.1 U34.2
N00044_USER_DESIGN_OUTPUTS0_DAAMP1: U36.1 U37.2
N00046_USER_DESIGN_OUTPUTS0_DAAMP0: R54.2 U33.8
N00046_USER_DESIGN_OUTPUTS0_DAAMP1: R56.2 U36.8
N00048_USER_DESIGN_OUTPUTS0_DAAMP0: R53.2 U33.2
N00048_USER_DESIGN_OUTPUTS0_DAAMP1: R55.2 U36.2
N00060_USER_DESIGN_OUTPUTS0_DAAMP0: U32.6 U34.3
N00060_USER_DESIGN_OUTPUTS0_DAAMP1: U35.6 U37.3
PGOOD: R2012.2 U51.9
Q1E: Q9.2(E) R52.2
Q2E: C68.2 Q8.2 R45.1 R47.2
R/W: U1.D3
RDY/: J6.E6 U7.19
RESET: R2008.2 U1.M12 U2.T11 U49.2 U50.11
RESET/: J6.E1 U48.3
RS: U1.D1
SEL: U7.11 U48.9
SHIELD1: J5.10
SHIELD2: J5.11
STDA_SSRX+: C2003.1 R2002.2 U2.A8
STDA_SSRX-: C2002.1 R2003.2 U2.B8
STDA_SSTX+: C2004.1 R2005.2 U2.E7
STDA_SSTX-: C2005.1 R2004.2 U2.E8
TCLK: P1.3 U1.C14 U2.C14
TDO: U1.E14 U2.C12
TMS: P1.11 U1.A15 U2.A15
V+12: C31.2 C32.2 C33.2 C39.2 C62.1 C64.1 C66.1 C199.1 C202.1 D5.1 J6.A1 J6.A2 J6.D1 J6.D2 R19.2 R45.2 U3.8 U5.1 U29.J1 U29.J2 U29.J3 U29.K1 U29.K2 U29.K3 U29.L1 U29.L2 U29.L3 U29.L5 U30.J1 U30.J2 U30.J3 U30.K1 U30.K2 U30.K3 U30.L1 U30.L2 U30.L3 U30.L5 U31.J1 U31.J2 U31.J3 U31.K1 U31.K2 U31.K3 U31.L1 U31.L2 U31.L3 U31.L5 U33.4 U34.7 U36.4 U37.7
VCLKC: R26.2 U39.11
VDX0: R8.2 RN2.5(2) U22.9 U38.9 U39.9 U48.11
VDX1: R6.2 RN2.6 U22.8 U38.8 U39.8 U48.12
VDX2: R4.2 RN2.7 U22.7 U38.7 U39.7 U48.13
VDX3: R2.2 RN2.8 U22.6 U38.6 U39.6 U48.14
VDX4: R7.2 RN3.5(2) U22.5 U38.5 U39.5 U48.15
VDX5: R5.2 RN3.6 U22.4 U38.4 U39.4 U48.16
VDX6: R3.2 RN3.7 U22.3 U38.3 U39.3 U48.17
VDX7: R1.2 RN3.8 U22.2 U38.2 U39.2 U48.18
VTTREF: C2016.1 U51.6
WAIT/: J6.E2 U48.2
N00286: C34.1 C35.1 C38.1 L5.2 L6.1
N00395: C35.2 C37.2 L6.2 R17.1
N00671: C3.1 R1.1
N00689: C5.1 R3.1
N00703: C7.1 R5.1
N00717: C9.1 R7.1
N00827: C4.1 R2.1
N00831: C6.1 R4.1
N00835: C8.1 R6.1
N00837: C10.1 R8.1
N04966: L7.1 L9.1
N44457: U1.K6 U10.8
N44464: U1.K3 U10.3 U10.13
N44478: U1.E2 U10.7
N44485: U1.L4 U10.10
N44490: U1.L5 U10.1
N45317: U2.M11 U11.1
N61996: C71.1 R50.2
N62056: Q8.1 R46.1 R51.1
N62230: C71.2 Q9.1 R48.1 R49.1
N62316: C72.2 Q8.3(E) R48.2
N62436: D5.3(C) R46.2
N62564: C69.1 C70.1 Q9.3 R47.1
N68133: C42.2 Q3.1 R21.1 R23.2
N70364: C43.2 Q3.2(E) R24.2
N80550: C40.2 R19.1
N81780: C69.2 R49.2
N84247: U6.22 U8.9 U8.12 U9.20
N103899: U6.19 U6.23 U8.8 U8.11 U9.19 U9.23
N108857: R12.2 U4.21
N108997: R14.2 U4.12
N111502: C11.1 C12.2 U3.1(OUT)
N111881: C11.2 C13.2 C14.2 R9.2 R10.2 R11.1
N113142: C15.2 L4.1 R9.1
N114006: C18.1 C20.1 Q1.1 R10.1 R13.2
N118214: C19.1 L3.3(OUT2) Q1.3
N118917: C16.2 L3.1 R11.2
N120412: C17.1 L3.2
N121910: C20.2 C21.2 Q1.2(E) R15.2
N123723: C17.2 Q2.3 R16.2
N124926: C19.2 C21.1 C22.2 Q2.1 R13.1 R15.1 R16.1 XTAL1.3
N129422: C22.1 L4.3(OUT2) Q2.2(S)
N221560: C18.2 XTAL1.4
N277989: Q3.3
N828385: R31.1 U22.19
N829333: R43.1 U31.G7
N829669: R44.1 U31.K7
N829685: U31.G5 U31.H5
N830942: D3.A R29.2
N831005: D3.C Q6.3
N831029: R39.1 U29.G7
N831181: R40.1 U29.K7
N831646: D2.A R28.2
N831650: D2.C Q5.3
N831853: R41.1 U30.G7
N831855: D1.A R27.2
N831859: D1.C Q4.3
N832005: R42.1 U30.K7
N832074: D4.A R30.2
N832078: D4.C Q7.3
N852308: R32.1 U22.17
N852494: R33.1 U22.15
N852683: R34.1 U22.13
N884986: C70.2 J3.1
N885188: C2.1 J2.1 L2.2
N885276: C1.1 J1.1 L1.2
N885442: L1.1 U34.6
N1358395: J5.6 R2003.1
N1358407: J5.8 R2004.1
N1358411: J5.9 R2005.1
N1358515: J5.2 R2000.1
N1358527: J5.3 R2001.1
N1358539: J5.5 R2002.1
N1406173: R2009.1 U50.9(XTAL2) Y1.3(OUTPUT)
N1406200: R2009.2 U50.8 Y1.1
N1406547: C2008.1 C2009.1 R2006.2 U50.4 U50.5
N1406997: R2007.1 U50.10 U50.19 U50.21
N1421557: L2.1 U37.6
N1432081: U2.M12 U11.8
N1432096: U2.R11 U11.3
N1432111: U2.P10 U11.7
N1432121: U2.T10 U11.10
N1438447: SW2.2 U49.3
N1472359: C2010.1 R2010.2 R2011.1 U51.1
N2993541: C43.1 R25.2

Pads without a net: D5 2; J6 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 A18 A19 A20 A21 A22 C3 C4 C5 C6 C7 C8 C9 C10 C11 C12 C13 C14 C15 C16 C17 C18 C19 C20 C21 C22 D5 D6 D7 D8 D9 D10 D11 D12 D13 D14 D15 D16 D17 D18 D19 D20 D21 D22 E7 F3 F4 F5 F6 F7 F8 F9 F10 F11 F12 F13 F14 F15 F16 F17 F18 F19 F20 F21 F22; J7 28 29 30 78 79 80 128 129 130 178 179 180; P1 10; SW2 3 4; U1 A2 A3 A4 A7 A8 A9 A10 A11 A12 A13 A14 B1 B2 B3 B8 B10 B12 B14 C2 C4 C7 C8 C9 C10 C11 C13 D8 D9 D11 D12 E1 E3 E4 E6 E7 E8 E10 E11 F1 F3 F4 F5 F6 F7 F9 F10 G1 G5 G12 H1 H2 H5 H11 H13 H14 J3 J11 J12 J13 J14 K1 K2 K11 K12 K14 K15 K16 L1 L3 L7 L10 L11 L12 L13 L14 L16 M3 M4 M5 M7 M10 M13 M14 M15 M16 N4 N6 N9 N12 N14 N16 P4 P7 P9 P12 P13 P14 P15 P16 R3 R5 T2 T3 T4 T5; U2 A3 A4 A7 A9 A10 A12 B14 B15 B16 C4 C7 C8 C9 C13 C15 C16 D8 D9 D12 D14 D16 E6 E12 E13 E15 E16 F6 F7 F9 F12 F13 F14 F15 F16 G6 G11 G12 G14 G16 H11 H13 H14 H15 H16 J6 J13 J14 J16 K6 K11 K12 K14 K15 K16 L8 L10 L11 L12 L13 L14 L16 M3 M9 M10 M13 M14 M15 M16 N8 N12 N14 N16 P4 P12 P13 P14 P15 P16 R3 R12 R14 R15 R16 T2 T8 T12 T13 T14 T15; U3 4 5; U4 13 14 15 16 17; U6 20; U9 22; U10 2 4 5 6 9 12 14 15 16 17; U11 2 4 5 6 9 12 13 14 15 16 17; U12 A2 E2 E8 G3 R3 R7 R8; U13 A2 E2 E8 G3 R3 R7 R8; U22 12 14 16 18; U29 G5 H7 J7; U30 G5 H7 J7; U31 H7 J7; U34 1 5 8; U37 1 5 8; U40 1 30; U41 1 30; U42 1 30; U43 1 30; U44 1 30; U45 1 30; U46 1 30; U47 1 30; U48 1 19; U50 6 7 16 24 26; XTAL1 5; Y1 2 4

## Via types
v1: diameter 0.5, hole 0.203, TOP to BOTTOM, 502 vias
v2: diameter 0.6, hole 0.3, TOP to BOTTOM, 727 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0V9: length 16
  TOP w0.102: U12.J2 v1(36.7,108.9) ; U13.J2 v1(37.5,95.1)
  TOP w0.2: v2(71.15,81.15) 71.17,81.17 U51.5 ; U51.3 70.57,82.8 70.57,82.8 v2(69.7,82.8)
  POWER w0.5: 49.5,79.36 P1.2 ; P1.2 51.1,79.36 ; P1.2 51.1,77.76 ; P1.2 49.5,77.76
  BOTTOM w0.5: v2(69.55,78.9) 70.75,78.9 C2013.1 C2012.1 C2011.1
1V2: length 31.2
  TOP w0.102: U1.H10 v1(44.9,126.2) ; U1.G9 v1(45.9,125.2) ; U2.K10 v1(61.25,94.15) ; U2.H8 v1(58.25,97.15) ; U1.J7 v1(48.9,128.2) ; U2.K8 v1(58.25,94.15) ; U1.H8 v1(47.9,126.2) ; U1.J9 v1(45.9,128.2) ; U2.H10 v1(61.25,97.15) ; U1.K10 v1(44.9,129.2) ; U2.G9 v1(60.25,98.15) ; U1.K8 v1(47.9,129.2) ; U2.G7 v1(57.25,98.15) ; U2.J7 v1(57.25,95.15) ; U2.J9 v1(60.25,95.15) ; U1.G7 v1(48.9,125.2)
  POWER w0.5: 46.96,79.36 P1.4 ; P1.4 48.56,79.36 ; P1.4 48.56,77.76 ; P1.4 46.96,77.76
  BOTTOM w0.5: C128.1 46,128.1 v1(45.9,128.2) ; C125.1 v1(49.15,103) ; C186.1 v2(70.39,99.8) ; v2(55.79,125.31) C183.1 C129.1 ; v2(59.78,85.75) 59.94,85.75 60.34,86.15 C178.1 C185.1 ; C184.1 v2(38.6,118.11) ; C181.1 v2(70.2,107.1) ; C179.1 v1(49.15,89.8) ; C127.1 v1(45.9,125.2) ; C132.1 v2(37.6,118.11) ; C180.1 v1(49.15,88.7) ; C182.1 v2(70.2,108.2) ; C131.1 v2(54.6,116.91) ; C133.1 v2(70.39,100.8) ; C126.1 v1(49.15,102) ; C130.1 v2(55.6,116.91)
  vias: v2(87.25,116.58) v2(87.25,115.82) v2(87.25,115.06) v2(88.01,116.58) v2(88.01,115.82) v2(88.01,115.06) v2(88.77,116.58) v2(88.77,115.82) v2(88.77,115.06)
1V8: length 72.8
  TOP w0.102: U12.J9 v1(36.7,102.5) ; U12.E9 v1(40.7,102.5) ; U12.M9 34.7,101.9 v1(35.2,101.4) ; U12.G7 v1(39.1,104.1) ; U12.J1 v1(36.7,109.7) ; U13.J9 v1(36.7,88.7) ; U2.R13 v1(64.25,89.15) ; U13.C7 v1(42.3,90.3) ; U13.J1 v1(37.5,95.9) ; U13.A1 v1(43.9,95.9) ; U12.C9 v1(42.3,102.5) ; U13.G1 v1(39.1,95.9) ; U12.A9 v1(43.9,102.5) ; U12.G9 v1(39.1,102.5) ; U12.C3 v1(42.3,108.1) ; U12.R1 v1(31.9,109.7) ; U13.E9 v1(40.7,88.7) ; U2.G4 v1(54.25,98.15) ; U2.B4 v1(54.25,103.15) ; U2.N15 v1(66.25,91.15) ; U12.C1 v1(42.3,109.7) ; U13.G7 v1(39.1,90.3) ; U2.N2 v1(52.25,91.15) ; U13.E1 v1(40.7,95.9) ; U13.C1 v1(42.3,95.9) ; U2.K4 v1(54.25,94.15) ; U13.R1 v1(31.7,96.1) ; U2.J2 v1(52.25,95.15) ; U2.B13 v1(64.25,103.15) ; U12.C7 v1(42.3,104.1) ; U12.G1 v1(39.1,109.7) ; U13.M9 v1(34.3,88.7) ; U2.B9 v1(60.25,103.15) ; U13.G9 v1(39.1,88.7) ; U2.D2 v1(52.25,101.15) ; U13.A9 v1(43.9,88.7) ; U13.C9 v1(42.3,88.7) ; U12.A1 v1(43.9,109.7) ; U2.N7 v1(57.25,91.15) ; U13.C3 v1(42.3,94.3) ; U12.E1 v1(40.7,109.7)
  TOP w0.2: U51.2 71.85,83.3 v2(72.35,82.8)
  TOP w0.5: C105.1 v2(72.3,89.38) ; C106.1 v2(74.03,93.2)
  INNER2 w0.5: 44.42,79.36 P1.6 ; P1.6 44.42,77.76 ; P1.6 46.02,77.76 ; P1.6 46.02,79.36
  BOTTOM w0.5: C75.1 v1(30.4,87.21) ; C196.1 v1(49.15,93.85) ; R2010.1 72.3,87.57 v2(72.3,89.38) 74.52,89.38 C2015.1 C2014.1 ; C87.1 v2(51.7,109.21) ; C139.1 v2(41,111.5) ; C142.1 v1(49.15,99.6) ; C79.1 v1(38.1,97.75) ; C135.1 v1(49.15,98.6) ; C137.1 v1(49.15,92.85) ; C77.1 v1(36.1,97.75) ; C187.1 v1(36.4,87.21) ; C138.1 v1(49.15,91.85) ; C84.1 v2(40,111.5) ; C136.1 v1(49.15,97.6) ; C78.1 v1(37.1,97.75) ; C85.1 48.5,95.7 v1(49.2,95.7) ; C192.1 v1(35.4,87.21) ; C140.1 v2(70.39,104.8) ; C143.1 v1(49.15,96.6) ; C88.1 v2(52.7,109.21) ; v1(41.1,97.75) C191.1 C76.1 ; C86.1 v2(53.7,109.21) ; C189.1 v1(34.4,87.21) ; C134.1 v1(49.15,90.85) ; C193.1 v2(36,111.5) ; C83.1 v2(39,111.5) ; C81.1 v2(42,111.5) ; C194.1 v2(37,111.5) ; C80.1 v1(39.1,97.75) ; C73.1 v1(32.4,87.21) ; C74.1 v1(31.4,87.21) ; C195.1 v2(50.7,109.21) ; C188.1 v1(40.1,97.75) ; C82.1 v2(38,111.5) ; C141.1 v2(70.39,98.8) ; C190.1 v1(33.4,87.21)
2V5: length 110.2
  TOP w0.1: v1(58.3,90.2) 58.3,90.15 58.75,89.7 U2.R8 ; U1.D2 v1(52.92,123.18)
  TOP w0.102: U1.K4 v1(51.9,129.2) ; U2.F11 v1(62.25,99.15) ; U2.D7 v1(57.25,101.15) ; U1.F8 v1(47.9,124.2) ; U1.L9 v1(45.9,130.2) ; U1.N7 v1(48.9,132.2) ; U1.E5 v1(50.9,123.2) ; U1.L6 v1(49.9,130.2) ; U1.H6 v1(49.9,126.2) ; U2.D10 v1(61.25,101.15) ; U1.R8 v1(47.9,134.2) ; U1.G4 v1(51.9,125.2) ; U1.N10 v1(44.9,132.2) ; U2.G10 v1(61.25,98.15) ; U1.G10 v1(44.9,125.2) ; U1.J10 v1(44.9,128.2) ; U2.D15 v1(66.25,101.15) ; U2.E5 v1(55.25,100.15) ; U1.F11 v1(43.9,124.2) ; U1.J2 v1(52.9,128.2) ; U2.N10 60.25,92.15 v1(60.25,92.2) ; U2.H6 v1(56.25,97.15) ; U1.N2 v1(53.9,132.2) ; U1.R13 v1(41.9,134.2) ; U2.L6 v1(56.25,93.15) ; U2.F8 v1(58.25,99.15) ; U1.R4 v1(51.9,134.2) ; U2.R4 v1(54.25,89.15) ; U2.J10 v1(61.25,95.15) ; U2.L9 v1(60.25,93.15)
  TOP w0.3: 68.69,120.25 v2(67.43,120.25) 67.45,120.27 67.45,120.65 67.7,120.9 U10.20 ; U11.19 73.72,97.68 73.55,97.5 73.55,97.03 v2(73.55,97.03) U11.20
  TOP w0.5: C177.1 v2(75.15,119.1) ; C124.1 v2(62.15,113.6) ; C176.1 59.55,129.75 v2(61.65,129.75) ; C123.1 v2(31.1,130.6)
  BOTTOM w0.5: 48.17,124.2 C147.1 ; C102.1 44.6,116.85 ; C102.1 C101.1 ; C102.1 C103.1 ; C119.1 50.6,116.85 ; C119.1 C116.1 ; C119.1 C153.1 ; C155.1 C154.1 ; C155.1 C157.1 ; C155.1 69.35,94.4 69.3,94.45 ; C154.1 69.4,95.4 69.35,95.35 ; C154.1 C173.1 ; C172.1 56.4,108 ; C172.1 C158.1 ; C172.1 57.15,107.35 ; C99.1 C170.1 ; C99.1 C144.1 ; C99.1 55,85.95 ; C170.1 C175.1 ; C170.1 56,85.9 ; 60.7,126.85 C169.1 ; C98.1 C97.1 ; C98.1 C116.1 ; C98.1 48.6,116.95 ; C97.1 C104.1 ; C97.1 47.6,116.85 ; 68.22,120.9 C149.1 ; C149.1 69.6,120.9 ; C149.1 68.8,121.45 ; C156.1 48.65,106.9 ; C156.1 C171.1 ; C156.1 48.1,106.32 ; C174.1 58,85.95 ; C174.1 58.45,85.3 58.75,85.6 ; C174.1 C175.1 ; C146.1 48.1,109.7 ; C146.1 C171.1 ; C146.1 48.8,108.9 ; 55.12,128.4 C117.1 55.7,128.95 ; 40.57,128.2 C96.1 ; C96.1 C120.1 ; C96.1 41.15,128.75 ; 50.5,127.05 C151.1 49.95,126.47 ; 34.01,78.56 P1.14 ; P1.14 35.06,79.61 ; P1.14 36.11,78.56 ; P1.14 35.06,77.51 ; 89.92,121.3 C148.1 ; C148.1 C100.1 ; C148.1 90.5,121.85 ; C120.1 42.15,128.65 42.2,128.7 ; C120.1 C121.1 43.15,128.75 ; 36.2,128.88 C152.1 36.75,128.3 ; C116.1 49.6,116.95 ; C104.1 C103.1 ; C104.1 46.6,116.9 ; C159.1 59.8,108 ; C159.1 60.6,107.25 ; C159.1 C89.1 ; C93.1 54.4,121.35 ; C171.1 48.85,107.9 ; 53.85,119.77 C92.1 54.4,120.35 ; 43.95,122.72 C94.1 43.95,123.88 ; C145.1 70.1,91.91 70.05,91.86 ; C145.1 69.3,92.4 69.25,92.35 ; C145.1 C157.1 ; C153.1 51.6,116.7 ; C153.1 52.18,116.15 ; C150.1 74.75,96.25 ; C150.1 75.33,95.7 ; C150.1 74.17,95.7 ; C158.1 58.73,108 ; C158.1 58.15,107.45 ; C101.1 42.75,116.15 ; C101.1 43.6,116.85 ; C100.1 92.08,121.3 ; C100.1 91.5,121.85 ; C157.1 69.3,93.4 ; C103.1 45.6,116.85 ; C175.1 57,85.95 ; 62.6,107.45 C90.1 ; C90.1 C89.1 ; C90.1 63.18,108 ; 53.42,85.3 C144.1 ; C144.1 54,85.85 ; C89.1 61.6,107.35 ; 44.73,128.2 C118.1 44.15,128.75 ; C173.1 70.1,96.98 ; C173.1 69.55,96.4 ; 36.2,125.72 C91.1 36.75,126.3 ; C95.1 36.75,127.3 ; C122.1 50.33,124.2
  vias: v2(97.41,116.33) v2(97.41,115.56) v2(97.41,114.8) v2(98.17,116.33) v2(98.17,115.56) v2(98.17,114.8)
3V3: length 46.6
  TOP w0.1: U2.J15 v1(66.25,95.15)
  TOP w0.102: U1.D15 v1(39.9,122.2) ; U2.K13 v1(63.25,94.15) ; U1.B4 v1(51.9,120.2) ; U1.D10 v1(44.9,122.2) ; U1.G13 v1(41.9,125.2) ; U1.J15 v1(39.9,128.2) ; U1.D7 v1(48.9,122.2) ; U1.N15 v1(39.9,132.2) ; U1.K13 v1(41.9,129.2) ; U1.B9 v1(45.9,120.2) ; U1.B13 v1(41.9,120.2) ; U2.G13 v1(64.25,98.15)
  TOP w0.2: v2(75.64,84.56) 75.63,84.55 74.5,84.55 74.12,84.17 U51.10 74.12,83.8 73.45,83.8 73.25,83.6 73.25,82.5 73.45,82.3 U51.7
  TOP w0.3: v2(76.1,98.35) 76.07,98.33 U11.18 ; U10.18 v2(69.94,119.6)
  TOP w0.5: U30.H5 v2(98.51,102.99) ; U29.H5 v2(89.21,102.99)
  INNER2 w0.5: 36.8,77.76 P1.12 ; P1.12 38.4,77.76 ; P1.12 38.4,79.36 ; P1.12 36.8,79.36
  BOTTOM w0.2: 67.8,127.2 68.45,127.2 v2(69.2,127.95) ; 67.8,127.2 67.8,127.6 ; 67.8,127.2 RN1.8 ; RN1.6 67.8,128 ; 67.8,128 67.8,127.6 ; 67.8,128 67.8,128.25 67.65,128.4 RN1.5 ; 67.8,127.6 RN1.7
  BOTTOM w0.5: C111.1 C110.1 C162.1 ; R2012.1 v2(75.64,84.56) ; C112.1 C167.1 C160.1 C163.1 35.3,123.8 v2(35.2,123.7) ; C162.1 v2(58.7,126.55) ; C162.1 C109.1 ; C166.1 v2(57.5,119.45) ; C165.1 v2(57.5,120.45) ; C114.1 v2(70.39,103.8) ; C113.1 C107.1 46.27,120.57 v1(45.9,120.2) 46.27,119.83 C161.1 C164.1 ; C168.1 v2(70.39,102.8) ; C108.1 v2(71,119.05) ; C115.1 v2(70.39,101.8)
  vias: v2(106.3,113.95) v2(106.3,113.2) v2(106.35,117.75) v2(106.35,117) v2(106.35,116.25) v2(106.35,115.5) v2(106.35,114.75) v2(107.06,117.78) v2(107.06,117.02) v2(107.06,116.26) v2(107.1,115.5) v2(107.1,114.75) v2(107.1,113.95) v2(107.1,113.15)
5V: length 125
  TOP w0.2: U4.11 v2(75.1,108.61) ; U4.23 79.95,111.86 v2(79.5,111.4) ; v2(72,111.3) 72.56,111.86 U4.6 ; U4.18 v2(82.3,108.61)
  TOP w0.5: U5.3 31.23,64.22 v2(31.2,64.25) ; XTAL1.2 XTAL1.1 v2(42.4,57.34) ; XTAL1.6 46.36,57.34 v2(46.35,57.35)
  INNER1 w0.5: v2(79.5,111.4) 79.1,111.4 78.7,111 78.7,108.5 ; 78.7,108.5 82.2,108.5 v2(82.3,108.61) ; 78.7,108.5 75.21,108.5 v2(75.1,108.61) ; v2(75.1,108.61) 75.1,108.48 75.25,108.33 75.25,85.47 73.7,83.92 73.7,80.55 69.15,76 69.15,70.7 55.79,57.34 46.36,57.34 v2(46.35,57.35) 46.34,57.34 v2(42.4,57.34) 39.4,60.34 39.4,62.25 37.4,64.25 v2(31.2,64.25) ; v2(75.1,108.61) 73.9,109.81 73.9,110.8 73.4,111.3 72.66,111.3 72.66,111.31 72.03,111.31 72.02,111.3 v2(72,111.3)
  BOTTOM w0.5: C26.1 C24.1 82.1,108.4 v2(82.3,108.61) ; v2(72,111.3) 72.02,111.3 72.03,111.31 72.91,111.31 C27.1 C30.1 ; v2(79.5,111.4) 80.1,111.4 C28.1 C29.1 ; v2(75.1,108.61) 75.1,108.6 C25.1 C23.1
GND EARTH: length 78.9
  TOP w0.5: SW1.8 v2(78.84,134.49) ; SW1.5 v2(78.84,126.87) ; SW1.7 v2(78.84,131.95) ; SW1.6 v2(78.84,129.41)
  GND w0.5: J2.5 119.53,64.99 ; J2.5 117.45,64.99 ; J2.5 119.53,67.08 ; J2.5 117.45,67.08 ; 117.45,51.6 J1.5 ; J1.5 119.53,49.51 ; J1.5 117.45,49.51 ; J1.5 119.53,51.6 ; J2.2 124.61,70.07 ; J2.2 122.53,72.16 ; J2.2 124.61,72.16 ; J2.2 122.53,70.07 ; J3.2 124.61,137.88 ; J3.2 124.61,139.97 ; J3.2 122.53,139.97 ; J3.2 122.53,137.88 ; 122.53,132.81 J3.3 ; J3.3 124.61,134.89 ; J3.3 122.53,134.89 ; J3.3 124.61,132.81 ; J2.4 119.53,72.16 ; J2.4 117.45,72.16 ; J2.4 117.45,70.07 ; J2.4 119.53,70.07 ; 117.45,134.89 J3.5 ; J3.5 117.45,132.81 ; J3.5 119.53,132.81 ; J3.5 119.53,134.89 ; 123.57,55.64 124.61,56.68 ; 123.57,55.64 122.53,54.59 ; 123.57,55.64 124.61,54.59 ; 123.57,55.64 122.53,56.68 ; 122.53,64.99 J2.3 ; J2.3 124.61,67.08 ; J2.3 124.61,64.99 ; J2.3 122.53,67.08 ; 117.45,54.59 118.49,55.64 ; 118.49,55.64 119.53,56.68 ; 118.49,55.64 117.45,56.68 ; 118.49,55.64 119.53,54.59 ; J1.3 124.61,49.51 ; J1.3 122.53,49.51 ; J1.3 124.61,51.6 ; J1.3 122.53,51.6 ; J3.4 119.53,139.97 ; J3.4 117.45,139.97 ; J3.4 117.45,137.88 ; J3.4 119.53,137.88
V12N: length 41.3
  TOP w0.5: U37.4 103.6,71.4 99.5,71.4 96.75,74.15 95.45,74.15 ; U34.4 104.02,56.35 99.1,56.35 96.78,58.67 95.45,58.67
  POWER w0.5: J6.D3 7.23,80.42 ; J6.D3 7.23,81.65 ; J6.D3 6,81.65 ; J6.D3 6,80.42 ; J6.D4 7.23,82.45 ; J6.D4 7.23,83.68 ; J6.D4 6,83.68 ; J6.D4 6,82.45 ; J6.A4 13.23,82.45 ; J6.A4 13.23,83.68 ; J6.A4 12,82.45 ; J6.A4 12,83.68 ; 103.74,56.07 U34.4 ; U34.4 105.31,57.64 ; U34.4 104.53,55.81 ; 104.53,71.29 U37.4 ; U37.4 103.74,71.55 ; U37.4 103.49,72.33 ; 12,81.65 J6.A3 ; J6.A3 13.23,80.42 ; J6.A3 12,80.42 ; J6.A3 13.23,81.65
VCC: length 337.1
  TOP w0.25: U50.28 68.28,82.3 v2(68.78,81.8) U50.27 ; U8.18 19.29,114.59 v2(19.3,114.6) ; U6.31 v2(26.87,131.36) ; U50.32 v2(68.78,84.3) ; v2(16.55,137) 16.69,136.86 U6.7 ; v2(26.9,103.5) 26.47,103.08 U9.42 ; U8.42 26.79,120.09 27.25,120.55 v2(27.45,120.55) ; U9.7 v2(16.69,103.08) ; U49.4 65.94,78.12 v2(66.46,77.59) ; U8.31 26.86,114.59 v2(27.1,114.35) ; U6.42 v2(26.87,136.86) ; U6.18 17.17,131.36 16.97,131.56 16.97,131.58 v2(16.75,131.8) ; U9.31 v2(26.75,97.58) ; v2(16.8,120.1) 16.81,120.09 U8.7 ; U9.18 16.72,97.58 v2(16.55,97.4)
  TOP w0.5: v2(88.7,58.45) 88.6,58.35 88.6,52.3 89.55,51.35 U32.2 ; v2(39.9,162.95) 39.9,162.42 39.4,161.92 U40.32 ; U48.20 v2(27.42,72.64) ; U32.9 v2(90.75,60.24) ; U47.32 v2(112.88,161.92) ; U35.2 v2(90.75,66.83) ; R28.1 v2(117.76,91.99) ; U45.32 v2(91.05,161.92) ; U43.32 v2(69.22,161.92) ; U41.32 50.37,161.92 51,162.55 v2(51,163) ; U46.32 v2(101.97,161.92) ; R30.1 v2(117.76,79.73) ; L10.1 v2(94.39,64.7) ; R29.1 v2(117.76,85.86) ; U42.32 v2(58.31,161.92) ; U38.20 v2(77.01,61.51) ; U7.20 v2(27.42,87.88) ; U44.32 v2(80.14,161.92) ; R27.1 v2(117.76,98.12) ; 109.65,93.81 v2(108.22,93.81) ; U39.20 v2(80.19,76.99)
  TOP w0.85: U32.2 94.03,51.35 L8.1 ; U35.9 v2(90.75,75.72)
  INNER1 w0.85: 51.6,225.76 55.66,225.76 56.94,227.04 91.82,227.04 93.1,225.76
  INNER2 w0.5: v2(58.31,161.92) 60.6,164.21 60.6,204.8 63.35,207.55 63.35,227.04
  POWER w0.5: 6,131.22 J6.D23 ; J6.D23 7.23,131.22 ; J6.D23 6,132.45 ; J6.D23 7.23,132.45 ; J6.A24 13.23,133.25 ; J6.A24 12,134.48 ; J6.A24 12,133.25 ; J6.A24 13.23,134.48 ; 6,134.48 J6.D24 ; J6.D24 7.23,133.25 ; J6.D24 7.23,134.48 ; J6.D24 6,133.25 ; J5.1 121.57,110.62 ; J5.1 121.57,109.38 ; J5.1 120.33,110.62 ; J6.A23 13.23,131.22 ; J6.A23 12,132.45 ; J6.A23 12,131.22 ; J6.A23 13.23,132.45
  BOTTOM w0.3: 44.65,143.9 44.7,143.85 45.1,143.85 45.25,144 J7.34 ; 44.65,143.9 44.65,142.6 44.95,142.3 v2(45.85,142.3) ; 44.65,143.9 J7.32 ; J7.87 64.75,152.5 64.55,152.3 64.15,152.3 ; v2(62.3,142.05) 63.25,142.05 ; 63.25,142.05 J7.82 ; 63.25,142.05 63.25,142.05 63.85,142.05 ; 94.15,151.75 J7.185 ; 94.15,151.75 93.55,151.75 ; 94.15,151.75 v2(94.55,151.75) 94.75,151.95 J7.187 ; 79.4,142.05 79.45,142.1 J7.136 ; 79.4,142.05 78.85,142.05 ; 79.4,142.05 79.7,142.05 80.05,142.4 J7.138 ; 64.45,142.05 64.75,142.05 65.05,142.35 J7.88 ; 64.45,142.05 J7.86 ; 64.45,142.05 63.85,142.05 ; J7.83 63.55,152.3 ; 63.55,152.3 64.15,152.3 ; 63.55,152.3 62.95,152.3 ; 78.85,142.05 v2(78.25,142.05) J7.132 ; 78.85,142.05 J7.134 ; 63.85,142.05 J7.84 ; 64.15,152.3 J7.85 ; 46.15,156.1 45.85,156.1 45.55,155.8 J7.35 ; 46.15,156.1 J7.37 ; 46.15,156.1 46.15,156.65 45.5,157.3 44.4,157.3 v2(44.35,157.35) 44.35,156.1 ; 78.94,155.9 79.15,155.69 J7.135 ; 78.94,155.9 v2(78.94,156.9) ; 78.94,155.9 78.85,155.9 78.55,155.6 J7.133 ; v2(93.25,141.95) 93.25,143.6 ; 93.25,143.6 J7.182 ; 93.25,143.6 93.85,143.6 ; 93.55,151.75 J7.183 ; 93.55,151.75 93.25,151.75 92.95,152.05 J7.181 ; 44.35,156.1 44.65,156.1 44.95,155.8 J7.33 ; 44.35,156.1 J7.31 ; v2(78.94,156.9) 79,156.9 79.75,156.15 J7.137 ; v2(78.94,156.9) 78.89,156.85 78.3,156.85 77.95,156.5 J7.131 ; 94.45,143.6 94.8,143.6 95.05,143.85 J7.188 ; 94.45,143.6 93.85,143.6 ; 94.45,143.6 J7.186 ; v2(45.85,142.3) 46.45,142.9 J7.38 ; v2(45.85,142.3) J7.36 ; 93.85,143.6 J7.184 ; J7.81 62.95,152.3 ; 62.95,152.3 62.4,152.3 v2(61.9,151.8)
  BOTTOM w0.5: v2(90.75,60.24) 91,60 C197.1 ; C48.1 92.27,161.92 v2(91.05,161.92) ; C55.1 114.73,161.92 v2(112.88,161.92) ; v2(26.87,131.36) 26.75,131.23 25.7,131.23 ; v2(51,163) 51,162.25 50.55,161.8 C49.1 ; C53.1 39.5,161.8 39.9,162.2 v2(39.9,162.95) ; C46.1 26.01,120.55 v2(27.45,120.55) ; R2008.1 v2(66.46,77.59) ; v2(80.14,161.92) 81.86,161.92 C52.1 ; v2(27.42,87.88) 27.4,87.89 C45.1 ; v2(90.75,75.72) 91,75.47 C200.1 ; v2(58.31,161.92) 58.32,161.93 C51.1 ; v2(26.75,97.58) 26.08,96.91 25.53,96.91 ; v2(68.78,81.8) 68.73,81.75 C2007.2 66.04,81.75 R2006.1 ; R2007.2 v2(67.6,78.95) ; C50.1 103.69,161.92 v2(101.97,161.92) ; C2006.1 27.4,72.65 v2(27.42,72.64) ; C54.1 70.95,161.92 v2(69.22,161.92)
0: length 703.7
  TOP w0.102: U13.F2 v1(39.9,95.1) ; U12.D8 v1(41.5,103.3) ; U2.E9 v1(60.25,100.15) ; U1.A1 v1(54.9,119.2) ; U13.P9 v1(32.7,88.7) ; U1.T16 v1(38.9,135.2) ; U13.B8 v1(43.1,89.5) ; U2.H9 v1(60.25,97.15) ; U13.B2 v1(43.1,95.1) ; U1.P3 v1(52.9,133.2) ; U1.J8 v1(47.9,128.2) ; U13.N1 v1(33.5,95.9) ; U2.R10 v1(61.25,89.15) ; U12.J7 v1(36.7,104.1) ; U2.L2 v1(52.25,93.15) ; U13.H8 v1(38.3,89.5) ; U2.A16 v1(67.25,104.15) ; U13.D2 v1(41.5,95.1) ; U12.F2 v1(39.9,108.9) ; U2.H7 v1(57.25,97.15) ; U2.H12 v1(63.25,97.15) ; U13.D8 v1(41.5,89.5) ; v1(52.4,98.15) 52.4,98 U2.G2 ; U12.N1 v1(33.5,109.7) ; U2.K9 v1(60.25,94.15) ; U1.L2 v1(53.9,130.2) ; U12.D2 v1(41.5,108.9) ; U1.M8 v1(47.9,131.2) ; U12.H2 v1(38.3,108.9) ; U1.L15 v1(39.9,130.2) ; U2.M8 v1(58.25,92.15) ; U12.A3 v1(43.9,108.1) ; U2.A1 v1(51.25,104.15) ; U1.K7 v1(48.9,129.2) ; U2.P3 v1(53.25,90.15) ; U13.H2 v1(38.3,95.1) ; U1.B11 v1(43.9,120.2) ; U1.D4 v1(51.9,122.2) ; U13.A3 v1(43.9,94.3) ; U1.R10 v1(44.9,134.2) ; U1.H12 v1(42.9,126.2) ; U1.R6 v1(49.9,134.2) ; U13.J7 v1(36.7,90.3) ; U1.G15 v1(39.9,125.2) ; U12.E3 v1(40.7,108.1) ; U13.A7 v1(43.9,90.3) ; U1.A16 v1(38.9,119.2) ; U2.N13 v1(64.25,91.15) ; U1.G2 v1(53.9,125.2) ; U1.J5 v1(50.9,128.2) ; U2.L15 v1(66.25,93.15) ; U2.D13 v1(64.25,101.15) ; U12.E7 v1(40.7,104.1) ; U1.H9 v1(45.9,126.2) ; U12.B2 v1(43.1,108.9) ; U2.R6 v1(56.25,89.15) ; U1.N13 v1(41.9,132.2) ; U2.D4 v1(54.25,101.15) ; U13.J3 v1(36.7,94.3) ; U2.T1 v1(51.25,88.15) ; U13.F8 v1(39.9,89.5) ; U12.P9 v1(32.7,102.5) ; U13.E3 v1(40.7,94.3) ; U2.J8 v1(58.25,95.15) ; U1.K9 v1(45.9,129.2) ; U12.A7 v1(43.9,104.1) ; U1.B7 v1(47.9,120.2) ; U1.D13 v1(41.9,122.2) ; U12.J3 v1(36.7,108.1) ; U12.H8 v1(38.3,103.3) ; U12.B8 v1(43.1,103.3) ; U2.J5 v1(55.25,95.15) ; U2.K7 v1(57.25,94.15) ; U2.G8 v1(58.25,98.15) ; U2.T16 v1(67.25,88.15) ; U2.B11 v1(62.25,103.15) ; U1.G8 v1(47.9,125.2) ; U1.H7 v1(48.9,126.2) ; U1.T1 v1(54.9,135.2) ; U12.F8 v1(39.9,103.3) ; U1.E9 v1(45.92,123.22) ; U13.E7 v1(40.7,90.3) ; U2.G15 v1(66.25,98.15) ; U2.B7 v1(57.25,103.15)
  TOP w0.2: U4.10 v2(72.34,109.25) ; U4.24 v2(82.3,112.5) ; U50.17 63.66,79.59 63.8,79.45 64,79.45 64.16,79.61 U50.18 ; U4.19 v2(79.54,109.25) ; v2(77.68,83.19) 77.29,82.8 U51.8 ; U51.4 70.6,82.3 70.3,82 v2(70.3,81.15) ; U4.5 v2(75.1,112.5) ; U8.48 24.19,123.09 v2(24.17,123.07)
  TOP w0.25: v2(115.05,87.7) Q6.2 ; v2(115.05,93.83) Q5.2 ; v2(115.05,99.96) Q4.2 ; v2(115.05,81.57) Q7.2
  TOP w0.3: 65.66,82.8 U50.33 ; 65.66,82.8 U50.29 v2(68.78,82.8) ; 65.66,82.8 66.16,83.3 U50.3 66.16,85.43 v2(66.66,85.93) U50.2 ; U50.33 65.16,82.3 U50.20 ; U50.33 65.16,82.8 U50.12 62.52,82.8 v2(62.02,82.3) U50.13 ; U50.25 v2(68.78,80.8) ; v2(16.85,127.5) 16.85,127.93 17.28,128.36 U6.24 ; U8.28 26.67,113.09 26.88,113.31 26.9,113.31 v2(27.05,113.45) ; U9.10 16.82,101.58 v2(16.65,101.4) ; U50.17 62.88,80.07 v2(62.85,80.1) ; U9.34 v2(26.75,99.08) ; U50.22 66.16,79.45 v2(66.65,78.95) 66.66,78.95 U50.23 ; U6.4 19.21,138.36 v2(19.45,138.6) ; U50.14 62.52,81.8 v2(62.02,81.3) U50.15 ; v2(67.65,85.9) 67.16,85.41 U50.1 ; U8.45 24.77,121.59 24.17,122.2 v2(24.17,123.07) ; U9.24 v2(16.69,94.58) ; v2(26.96,135.36) 26.54,135.36 26.53,135.36 U6.39 ; 68.69,115.05 v2(69.94,115.05) ; U6.28 v2(26.87,129.86) ; U6.10 19.01,135.36 v2(19.6,135.95) ; U9.4 v2(16.69,104.58) ; U6.25 v2(24.41,128.36) ; U8.21 19.01,113.09 v2(19.4,112.7) ; v2(26.9,118.6) 26.89,118.59 U8.39 ; v2(27.1,133.35) 26.61,132.86 U6.34 ; U6.21 16.94,129.86 v2(16.75,130.05) ; U9.21 v2(16.69,96.08) ; U6.45 v2(26.87,138.36) ; v2(15.9,99.6) 16.42,99.08 U9.15 ; U9.45 v2(26.75,104.58) ; U9.25 v2(26.75,94.58) ; U9.28 v2(26.75,96.08) ; U6.15 17.17,132.86 17.17,132.86 16.74,132.86 v2(16.55,133.05) ; U8.34 v2(26.87,116.09) ; U9.39 v2(26.75,101.58) ; U8.10 v2(16.81,118.59) ; U8.1 v2(16.81,123.09) ; U11.11 v2(76.06,102.88) ; U8.4 v2(16.81,121.59) ; U8.15 v2(16.81,116.09)
  TOP w0.5: v2(60.4,125.25) 60.4,124.4 C176.2 ; C106.2 v2(76.87,93.2) ; R25.1 v2(86.36,127.8) ; U32.1 v2(90.75,50.08) ; U36.3 v2(98.73,75.42) ; U42.24 v2(58.35,151.76) ; U7.10 v2(15.26,76.45) ; U43.16 v2(66,142.87) ; U49.1 v2(62.43,78.12) ; C68.1 v2(94.96,136.03) ; R51.2 97.35,134.92 v2(97.35,134.4) ; U33.3 v2(98.73,59.94) ; v2(70.85,65.7) 70.71,65.56 U39.10 ; U47.16 v2(109.24,142.87) ; U46.24 v2(105.35,151.76) ; C15.1 v2(43.18,71.33) ; U35.7 v2(90.75,73.18) ; U32.10 v2(90.75,61.51) ; U40.16 v2(32.84,142.87) ; C38.2 v2(110.63,127.71) ; U32.7 v2(90.75,57.7) ; v2(33.5,70.55) 33.56,70.49 U3.2 36.38,70.49 C12.1 ; U42.16 v2(54.67,142.87) ; v2(30.95,70.6) 30.84,70.49 U3.7 ; C72.1 v2(96.83,131.31) ; C14.1 v2(42.14,71.2) ; U41.16 v2(43.76,142.87) ; U44.24 v2(80.14,151.76) ; C36.1 v2(110.63,122.71) ; U32.3 91.43,52.62 91.13,52.33 90.83,52.62 v2(90.75,52.62) ; v2(89.8,124.75) 90.14,124.75 R18.1 ; U35.3 v2(90.75,68.1) ; C37.1 96.3,124.37 96.3,124.91 v2(96.34,124.91) ; U35.10 v2(90.75,76.99) ; U47.24 v2(112.88,151.76) ; U44.16 74.88,142.87 75.45,142.3 v2(75.45,141.35) ; U41.24 50.69,151.76 v2(50.7,151.75) ; C16.1 v2(42.8,67.4) ; v2(41.65,66.6) 41.65,66.65 41.65,66.65 C13.1 ; U40.24 v2(36.48,151.76) ; 100.15,93.81 v2(101.58,93.81) ; U3.6 v2(30.78,71.76) ; U22.10 v2(101.58,82.39) ; C39.1 v2(86.36,136) ; U45.24 v2(91.05,151.76) ; C40.1 v2(86.07,135.12) ; v2(69.95,110.2) C124.2 ; U39.1 v2(67.66,76.99) ; v2(84.35,142.05) 84.35,142.37 84.85,142.87 U45.16 ; U48.10 v2(15.26,61.21) ; U35.1 v2(90.75,65.56) ; R23.1 v2(90.69,127.31) ; U3.3 v2(33.62,71.76) ; 82.73,65.56 v2(81.35,65.56) ; SW2.1 v2(59.25,76.05) ; 82.73,50.08 v2(84.11,50.08) ; R24.1 v2(88.65,127.8) ; U38.1 v2(67.66,61.51) ; U38.10 v2(70.53,50.08) ; C105.2 v2(80.18,87.65) ; C177.2 v2(81.35,119.05) ; R52.1 v2(112.78,124.73) ; v2(98.35,142.87) U46.16
  TOP w0.6: v2(72.6,152) 72.36,151.76 U43.24 ; C123.2 v2(31.1,133.05)
  GND w0.5: 118.83,114.12 J5.7 ; J5.7 119.45,112.7 ; J5.7 118.83,112.88 ; 120.33,116.38 J5.4 ; J5.4 120.95,116.2 ; J5.4 121.57,116.38 ; 39.34,81.9 P1.9 ; P1.9 39.34,80.3 ; P1.9 40.94,80.3 ; P1.9 40.94,81.9 ; J6.F2 3.73,79.91 ; J6.F2 3.73,81.14 ; J6.F2 2.5,81.14 ; J6.F2 2.5,79.91 ; P1.5 46.02,81.9 ; P1.5 44.42,81.9 ; P1.5 44.42,80.3 ; P1.5 46.02,80.3 ; 8.5,133.76 J6.C23 ; J6.C23 9.73,134.99 ; J6.C23 9.73,133.76 ; J6.C23 8.5,134.99 ; P1.1 51.1,81.9 ; P1.1 49.5,81.9 ; P1.1 49.5,80.3 ; P1.1 51.1,80.3 ; 8.5,135.79 J6.C24 ; J6.C24 9.73,137.02 ; J6.C24 9.73,135.79 ; J6.C24 8.5,137.02 ; 2.5,134.99 J6.F23 ; J6.F23 2.5,133.76 ; J6.F23 3.73,134.99 ; J6.F23 3.73,133.76 ; 34.01,81.1 P1.13 ; P1.13 35.06,82.15 ; P1.13 35.06,80.05 ; P1.13 36.11,81.1 ; J6.F24 3.73,135.79 ; J6.F24 2.5,137.02 ; J6.F24 3.73,137.02 ; J6.F24 2.5,135.79 ; 8.5,79.91 J6.C2 ; J6.C2 9.73,79.91 ; J6.C2 8.5,81.14 ; J6.C2 9.73,81.14 ; J6.F1 3.73,79.11 ; J6.F1 2.5,79.11 ; J6.F1 2.5,77.88 ; J6.F1 3.73,77.88 ; 8.5,77.88 J6.C1 ; J6.C1 9.73,79.11 ; J6.C1 8.5,79.11 ; J6.C1 9.73,77.88
  INNER2 w0.5: 72.6,151.66 v2(72.6,152) ; v2(72.6,152) 72.6,152.3 ; v2(72.6,152) 72.09,152 ; v2(72.6,152) 72.89,152 ; 112.38,160.05 v2(112.65,160.05) ; v2(112.65,160.05) 112.65,160.31 ; v2(112.65,160.05) 113.22,160.05 ; v2(112.65,160.05) 112.65,159.76 ; v2(66.2,148.1) 66.2,148.51 ; v2(66.2,148.1) 66.49,148.1 ; v2(66.2,148.1) 66.2,147.81 ; v2(66.2,148.1) 65.77,148.1 ; J6.C23 9.75,135.01 ; J6.C23 8.48,135.01 ; J6.C23 9.75,133.74 ; J6.C23 8.48,133.74 ; J6.C24 9.75,135.77 ; J6.C24 8.48,137.04 ; J6.C24 9.75,137.04 ; J6.C24 8.48,135.77 ; 50.71,229.19 51.6,228.3 ; 51.6,228.3 50.71,227.41 ; 51.6,228.3 52.49,227.41 ; 51.6,228.3 52.49,229.19 ; 93.1,223.22 93.8,222.52 ; 93.1,223.22 92.4,223.92 ; 93.1,223.22 93.8,223.92 ; 93.1,223.22 92.4,222.52 ; J6.F23 3.75,133.74 ; J6.F23 3.75,135.01 ; J6.F23 2.48,135.01 ; J6.F23 2.48,133.74 ; 2.48,137.04 J6.F24 ; J6.F24 2.48,135.77 ; J6.F24 3.75,137.04 ; J6.F24 3.75,135.77 ; 89.93,161.35 v2(90.4,161.35) 90.4,160.98 ; v2(65.95,152.4) 65.95,152.65 ; v2(65.95,152.4) 65.71,152.4 ; v2(65.95,152.4) 65.95,152.16 ; v2(65.95,152.4) 66.55,152.4 ; 93.1,228.3 93.99,229.19 ; 93.1,228.3 93.99,227.41 ; 93.1,228.3 92.21,227.41 ; 93.1,228.3 92.21,229.19 ; 98.35,152 v2(98.35,152.4) ; v2(98.35,152.4) 97.95,152.4 ; v2(98.35,152.4) 98.8,152.4 ; 50.9,223.92 51.6,223.22 ; 51.6,223.22 50.9,222.52 ; 51.6,223.22 52.3,222.52 ; 51.6,223.22 52.3,223.92
  BOTTOM w0.3: 80.95,155.85 80.35,155.85 ; 80.95,155.85 J7.141 ; 80.95,155.85 81.55,155.85 ; 80.35,155.85 80.35,156.5 v2(79.9,156.95) ; 80.35,155.85 J7.139 ; J7.192 96.25,147.9 ; 96.25,147.9 96.85,147.9 ; 96.25,147.9 95.95,147.9 95.65,147.6 J7.190 ; 51.25,143.35 51.25,143.95 ; 51.25,143.35 51.2,143.3 48.65,143.3 47.05,144.9 J7.40 ; 51.25,143.35 51.25,141.95 v2(50.3,141) ; 51.25,143.95 51.85,143.95 ; 51.25,143.95 J7.42 ; 83.05,142.05 J7.148 ; 83.05,142.05 82.45,142.05 ; 83.05,142.05 83.1,142.05 83.3,142.25 83.3,142.49 83.65,142.84 J7.150 ; J7.93 66.55,152.3 ; 66.55,152.3 67.15,152.3 ; 66.55,152.3 66.05,152.3 v2(65.95,152.4) ; 50.95,152.75 J7.41 ; 50.95,152.75 51.55,152.75 ; 50.95,152.75 50.75,152.55 50.75,151.8 v2(50.7,151.75) 49.85,151.75 49.3,152.3 49.3,153.85 48.8,154.35 J7.39 ; 51.85,143.95 J7.44 ; 51.85,143.95 52.45,143.95 ; J7.95 67.15,152.3 ; 67.15,152.3 67.45,152.3 67.75,152.6 ; 81.85,142.05 82.45,142.05 ; 81.85,142.05 81.25,142.05 ; 81.85,142.05 J7.144 ; 82.45,142.05 J7.146 ; 81.25,142.05 v2(80.65,142.05) J7.140 ; 81.25,142.05 J7.142 ; 51.55,152.75 52.15,152.75 ; 51.55,152.75 J7.43 ; C2007.1 68.5,82.8 v2(68.78,82.8) ; 67.47,84.96 67.65,85.13 v2(67.65,85.9) ; 82.75,155.85 82.15,155.85 ; 82.75,155.85 J7.147 ; 82.75,155.85 83.05,155.85 83.35,155.55 J7.149 ; 82.15,155.85 81.55,155.85 ; 82.15,155.85 J7.145 ; J7.198 98.05,147.9 ; 98.05,147.9 97.45,147.9 ; 98.05,147.9 v2(98.65,147.9) J7.200 ; 97.75,152.4 97.15,152.4 ; 97.75,152.4 J7.197 ; 97.75,152.4 v2(98.35,152.4) J7.199 ; 97.15,152.4 96.55,152.4 ; 97.15,152.4 J7.195 ; J7.91 v2(65.95,152.4) ; v2(65.95,152.4) 65.9,152.35 65.55,152.35 65.35,152.55 J7.89 ; J7.90 65.65,147.55 v2(66.2,148.1) ; 68,148.1 67.45,148.1 ; 68,148.1 68.05,148.05 J7.98 ; 68,148.1 68.2,148.1 68.65,147.65 J7.100 ; 67.45,148.1 66.85,148.1 ; 67.45,148.1 J7.96 ; J7.194 96.85,147.9 ; 96.85,147.9 97.45,147.9 ; 81.55,155.85 J7.143 ; 96.55,152.4 J7.193 ; 96.55,152.4 95.95,152.4 ; 67.75,152.6 68.35,153.2 J7.99 ; 67.75,152.6 J7.97 ; J7.50 53.65,144.3 53.3,143.95 53.05,143.95 ; 52.15,152.75 J7.45 ; 52.15,152.75 52.75,152.75 ; J7.191 95.95,152.4 ; 95.95,152.4 95.75,152.4 95.35,152.8 J7.189 ; 52.75,152.75 52.95,152.75 53.35,153.15 J7.49 ; 52.75,152.75 J7.47 ; 97.45,147.9 J7.196 ; 66.85,148.1 J7.94 ; 66.85,148.1 v2(66.2,148.1) ; 53.05,143.95 52.45,143.95 ; 53.05,143.95 J7.48 ; 52.45,143.95 J7.46 ; v2(66.2,148.1) 66.25,148.05 J7.92
  BOTTOM w0.5: R41.2 v2(102.75,102.7) ; C28.2 C29.2 82.11,112.7 v2(82.3,112.5) ; R43.2 v2(112.4,102.25) ; C199.2 98.87,59.8 v2(98.73,59.94) ; v2(100.9,159.4) 101.63,160.13 C50.2 ; v2(58.46,125.31) C183.2 C129.2 ; C94.2 45.03,123.22 v1(45.92,123.22) ; C131.2 v2(54.6,113.9) ; v2(90.75,52.62) 90.98,52.4 C198.2 ; C190.2 v2(33.4,84.59) ; C99.2 v2(55,83.5) ; C135.2 v1(46.65,98.6) ; C2016.2 v2(77.68,83.19) ; v2(112.48,108.07) C2004.2 C2005.2 C2001.2 C2000.2 C2002.2 C2003.2 ; C2006.2 27.15,70.85 v2(27.65,71.35) ; v2(68.5,85.9) 68.5,86.55 C2008.2 ; v2(67.66,76.99) 67.82,77.15 C2013.2 C2012.2 C2011.2 ; v2(57.8,159.4) 58.53,160.13 C51.2 ; C87.2 v2(51.7,106.59) ; C149.2 68.35,119.45 67.35,119.45 v2(67.35,119.45) ; C193.2 v2(36,114.11) ; C82.2 v2(38,114.11) ; C115.2 v2(73,101.8) ; C189.2 v2(34.4,84.59) ; C126.2 v1(46.65,102) ; C121.2 C118.2 ; C121.2 C120.2 C96.2 ; C121.2 43.15,126.45 v1(42.9,126.2) ; C140.2 v2(73,104.8) ; C181.2 v2(67.59,107.1) ; C74.2 v2(31.4,84.59) ; v2(34.39,128.3) C152.2 C95.2 C91.2 ; C158.2 v2(58.15,109.81) ; C77.2 v1(36.1,100.25) ; v2(90.75,78.25) 90.8,78.3 C10.2 C8.2 C6.2 C4.2 C9.2 C7.2 C5.2 ; C171.2 v2(46.3,107.9) ; v2(37.9,120.75) 37.15,120.75 C112.2 C167.2 C160.2 C163.2 ; C84.2 v2(40,114.11) ; C192.2 v2(35.4,84.59) ; v2(80.18,87.65) 79.38,86.85 C2014.2 C2015.2 ; C187.2 v2(36.4,84.59) ; C44.2 26.21,95.11 v2(26.75,94.58) ; C166.2 v2(60.1,119.45) ; v2(68.5,161.25) 69.62,160.13 C54.2 ; C185.2 C178.2 60.25,84.8 v2(58.95,84.8) 58.45,84.3 C174.2 C175.2 C170.2 ; C200.2 91.04,77.28 v2(90.75,76.99) ; C114.2 v2(73,103.8) ; R12.1 76.6,111.8 75.89,112.5 v2(75.1,112.5) 75.01,112.6 C30.2 C27.2 ; C73.2 v2(32.4,84.59) ; v1(46.65,95.7) 47.3,95.7 C85.2 ; C137.2 v1(46.65,92.85) ; C47.2 26.13,129.86 v2(26.87,129.86) ; C102.2 v2(44.6,113.94) ; v2(46.8,159.42) 46.8,159.45 47.35,160 C49.2 ; C5.2 v2(89.4,92.6) ; C5.2 C3.2 ; C138.2 v1(46.65,91.85) ; C159.2 v2(60.6,109.81) ; v2(79.25,159.42) 79.25,159.45 79.93,160.13 C52.2 ; v2(24.17,123.07) 24.48,122.76 C46.2 ; C101.2 v2(43.6,113.94) ; C186.2 v2(73,99.8) ; v2(90.75,68.1) 90.98,67.88 92.13,67.88 ; C128.2 46,126.2 v1(45.9,126.2) ; C133.2 v2(73,100.8) ; R40.2 v2(89.1,100.5) ; C86.2 v2(53.7,106.59) ; v2(33.5,70.55) 34.55,70.55 C31.1 ; C113.2 C107.2 47.27,120.83 v1(47.9,120.2) 47.27,119.57 C161.2 C164.2 ; C79.2 v1(38.1,100.25) ; R39.2 v2(93.3,102.5) ; C156.2 v2(46.3,106.9) ; C92.2 C93.2 52.75,121.35 v1(51.9,122.2) ; C108.2 v2(71,121.65) ; C80.2 v1(39.1,100.25) ; C125.2 v1(46.65,103) ; v2(72.34,109.25) 72.69,109.6 C23.2 C25.2 ; v1(45.92,123.22) 45.92,123.7 46.42,124.2 C127.2 ; v1(45.92,123.22) 47.95,123.22 47.97,123.2 C147.2 C122.2 ; C98.2 C97.2 v2(47.6,113.94) ; v2(49.6,113.94) C116.2 C119.2 C153.2 ; R14.1 79.1,108 79.45,108.35 79.45,109.16 v2(79.54,109.25) 79.69,109.4 C26.2 C24.2 ; v1(48.9,126.2) 48.9,127 C151.2 ; v2(112.65,160.05) 114.66,160.05 C55.2 ; C182.2 v2(67.59,108.2) ; C134.2 v1(46.65,90.85) ; C141.2 v2(73,98.8) ; C75.2 v2(30.4,84.59) ; C165.2 v2(60.1,120.45) ; C136.2 v1(46.65,97.6) ; C150.2 v2(76.1,94.7) ; C143.2 v1(46.65,96.6) ; C90.2 v2(62.6,109.81) ; C142.2 v1(46.65,99.6) ; C88.2 v2(52.7,106.59) ; C53.2 36.65,160 36.1,159.45 v2(36.1,159.42) ; C179.2 v1(46.65,89.8) ; C172.2 v2(57.15,109.81) ; C89.2 v2(61.6,109.81) ; C81.2 v2(42,114.11) ; C111.2 C110.2 C162.2 C109.2 C169.2 62.6,128.4 v2(63.2,127.8) ; v2(71.91,95.4) C154.2 C155.2 C157.2 C145.2 ; C144.2 v2(54,83.5) ; R2011.2 72.2,81.8 71.19,82.81 C2010.2 70.8,82.81 70.3,82.31 v2(70.3,81.15) ; C146.2 v2(46.3,108.9) ; v2(90.5,119.45) C148.2 C100.2 ; C202.2 98.87,75.28 v2(98.73,75.42) ; R44.2 v2(108.05,100.4) ; C139.2 v2(41,114.11) ; C132.2 v2(37.6,115.5) ; C180.2 v1(46.65,88.7) ; C197.2 91.04,61.8 v2(90.75,61.51) ; C130.2 v2(55.6,113.9) ; C45.2 v2(27.39,86.09) ; v2(90.4,161.35) 90.4,161.05 90.9,160.55 C48.2 ; C32.1 31.08,70.73 v2(30.95,70.6) 29.79,70.6 C33.1 ; C188.2 v1(40.1,100.25) ; C184.2 v2(38.6,115.5) ; C76.2 C191.2 v1(41.1,100.25) ; C168.2 v2(73,102.8) ; C78.2 v1(37.1,100.25) ; C103.2 v2(45.6,113.94) ; C83.2 v2(39,114.11) ; C173.2 v2(71.91,96.4) ; C196.2 v1(46.65,93.85) ; C194.2 v2(37,114.11) ; C195.2 v2(50.7,106.59) ; R42.2 v2(98.5,100.4) ; C104.2 v2(46.6,113.94) ; C117.2 v2(55.7,126.59)
  vias: v2(31.95,61.5) v2(31.95,60.23) v2(31.95,58.96) v2(33.22,61.5) v2(33.22,60.23) v2(33.22,58.96) v2(34.49,61.5) v2(34.49,60.23) v2(34.49,58.96) v2(35.76,61.5) v2(35.76,60.23) v2(35.76,58.96) v2(37.03,61.5) v2(37.03,60.23) v2(37.03,58.96) v2(38.3,61.5) v2(38.3,60.23) v2(38.3,58.96) v2(90.2,114.2) v2(90.2,113.4) v2(91,114.2) v2(91,113.4) v2(91.8,114.2) v2(91.8,113.4) v2(92.6,114.2) v2(92.6,113.4) v2(99.2,114.2) v2(99.2,113.4) v2(100,114.2) v2(100,113.4) v2(100.8,114.2) v2(100.8,113.4) v2(109,114.2) v2(109,113.4) v2(109.8,114.2) v2(109.8,113.4) v2(110.6,114.2) v2(110.6,113.4) v2(111.4,114.2) v2(111.4,113.4)
A0: length 19.7
  TOP w0.2: J6.B8 10.92,94.8 15.35,94.8 16.2,93.95 18.7,93.95 19.65,94.9 19.65,96.69 19.8,96.85 19.8,98.69 21.16,100.05 23.7,100.05 23.73,100.08 U9.36
A1: length 20.9
  TOP w0.2: J6.B7 10.8,92.28 10.8,93.05 11.95,94.2 15.2,94.2 15.85,93.55 18.87,93.55 20.05,94.73 20.05,96.45 20.3,96.7 20.3,98.6 21.27,99.58 U9.35
A2: length 22.3
  TOP w0.2: U9.33 23.32,98.58 v2(23.05,98.85)
  INNER1 w0.2: J6.B6 15.37,89.67 17.7,92 17.7,98 18.8,99.11 22.79,99.11 v2(23.05,98.85)
A3: length 23.2
  TOP w0.2: v2(22.3,98.5) 22.72,98.08 U9.32
  INNER1 w0.2: v2(22.3,98.5) 22.09,98.71 19,98.71 18.1,97.81 18.1,91.83 13.4,87.13 J6.B5
A4: length 23.1
  TOP w0.2: v2(23.05,97.1) 25.49,97.1 U9.30
  INNER1 w0.2: v2(23.05,97.1) 23,97.15 20.7,97.15 18.5,94.95 18.5,91.67 15.4,88.57 15.4,86.4 13.59,84.59 J6.B4
A5: length 24.3
  TOP w0.2: U9.29 23.97,96.58 23.8,96.4 21.31,96.4 20.6,95.69 20.6,93.95 20.42,93.78 13.85,87.2 13.85,82.7 13.2,82.05 J6.B3
A6: length 27.6
  TOP w0.2: v2(23.15,95.75) 23.32,95.58 U9.27
  INNER1 w0.2: J6.B2 14.26,79.51 15.8,81.05 15.8,88.4 18.9,91.5 18.9,94.7 19.95,95.75 21.6,95.75 21.61,95.75 v2(23.15,95.75)
A7: length 29
  TOP w0.2: U9.26 25.49,95.1 21.4,95.1 v2(21.35,95.15)
  INNER1 w0.2: v2(21.35,95.15) 19.92,95.15 19.3,94.53 19.3,91.34 16.2,88.24 16.2,79.8 13.37,76.97 J6.B1
A8: length 81.7
  TOP w0.2: U8.47 26.44,122.59 26.7,122.85 26.7,127.79 27.7,128.8 27.7,138.65 27.85,138.8 27.85,140 23.45,144.4 18.93,144.4 18.88,144.41 3.61,144.41 1.93,142.74 1.93,118.72 4.15,116.5 5.3,116.5 6.73,115.07 J6.B16
A9: length 87
  TOP w0.2: J6.B15 6.2,112.53 3.68,115.05 2.45,115.05 1.54,115.97 1.54,142.9 3.44,144.81 18.91,144.81 18.96,144.8 23.62,144.8 28.25,140.17 28.25,138.63 28.1,138.49 28.1,128.63 27.1,127.63 27.1,122.35 26.84,122.09 U8.46
A10: length 92.1
  TOP w0.2: J6.B14 10.86,110 6.06,110 3.91,112.15 2.65,112.15 1.13,113.67 1.13,143.07 3.28,145.21 18.95,145.21 19,145.2 23.78,145.2 28.65,140.34 28.65,138.46 28.5,138.32 28.5,128.47 27.5,127.46 27.5,122.1 26.49,121.09 U8.44 25.64,121.04
A11: length 98
  TOP w0.2: J6.B13 6.3,107.45 5.45,108.3 4.25,108.3 4.07,108.12 2.27,108.12 0.73,109.67 0.73,143.24 3.11,145.61 18.99,145.61 19.04,145.6 23.95,145.6 29.05,140.5 29.05,138.3 28.9,138.15 28.9,128.3 27.9,127.3 27.9,121.93 27.7,121.73 27.7,121.7 26.59,120.59 U8.43
A12: length 30.2
  TOP w0.2: U8.41 26.84,119.59 26.85,119.6 27.13,119.6 v2(27.18,119.55)
  INNER1 w0.2: v2(27.18,119.55) 27.08,119.65 24.76,119.65 24.75,119.66 24.25,119.66 24.24,119.65 22.19,119.65 21.64,119.1 21.64,115.52 19.72,113.59 19.44,113.59 18.79,112.95 14.2,112.95 13.65,112.4 13.65,105.4 13.16,104.91 J6.B12
A13: length 28.2
  TOP w0.2: v2(24.5,119.05) 24.55,119.1 25.64,119.1 U8.40
  INNER1 w0.2: v2(24.5,119.05) 24.4,118.95 23.2,118.95 23.05,118.81 23.05,117.75 22.2,116.89 22.2,115.51 20,113.32 20,111.31 18.5,109.8 14.35,109.8 14.05,109.5 14.05,102.95 13.47,102.37 J6.B11
